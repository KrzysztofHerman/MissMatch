v {xschem version=3.4.6 file_version=1.2}
G {}
K {type=schematic}
V {}
S {}
E {}
N 300 540 480 540 {lab=D[0:15]}
N 300 580 480 580 {lab=G[0:15]}
N 300 620 480 620 {lab=S[0:15]}
N 300 660 480 660 {lab=B}
N 8340 1240 9740 1240 {lab=G[0]}
N 8340 1600 9740 1600 {lab=G[1]}
N 8340 1960 9740 1960 {lab=G[2]}
N 8340 2320 9740 2320 {lab=G[3]}
N 8340 2680 9740 2680 {lab=G[4]}
N 8340 3040 9740 3040 {lab=G[5]}
N 8340 3400 9740 3400 {lab=G[6]}
N 8340 3760 9740 3760 {lab=G[7]}
N 8340 4120 9740 4120 {lab=G[8]}
N 8340 4480 9740 4480 {lab=G[9]}
N 8340 4840 9740 4840 {lab=G[10]}
N 8340 5200 9740 5200 {lab=G[11]}
N 8340 5560 9740 5560 {lab=G[12]}
N 8340 5920 9740 5920 {lab=G[13]}
N 8340 6280 9740 6280 {lab=G[14]}
N 8340 6640 9740 6640 {lab=G[15]}
N 8380 1510 9740 1510 {lab=S[0]}
N 8380 1870 9740 1870 {lab=S[1]}
N 8380 2230 9740 2230 {lab=S[2]}
N 8380 2590 9740 2590 {lab=S[3]}
N 8380 2950 9740 2950 {lab=S[4]}
N 8380 3310 9740 3310 {lab=S[5]}
N 8380 3670 9740 3670 {lab=S[6]}
N 8380 4030 9740 4030 {lab=S[7]}
N 8380 4390 9740 4390 {lab=S[8]}
N 8380 4750 9740 4750 {lab=S[9]}
N 8380 5110 9740 5110 {lab=S[10]}
N 8380 5470 9740 5470 {lab=S[11]}
N 8380 5830 9740 5830 {lab=S[12]}
N 8380 6190 9740 6190 {lab=S[13]}
N 8380 6550 9740 6550 {lab=S[14]}
N 8380 6910 9740 6910 {lab=S[15]}
N 1560 6370 1560 6730 {lab=D[0]}
N 2020 6370 2020 6730 {lab=D[1]}
N 2480 6370 2480 6730 {lab=D[2]}
N 2940 6370 2940 6730 {lab=D[3]}
N 3400 6370 3400 6730 {lab=D[4]}
N 3860 6370 3860 6730 {lab=D[5]}
N 4320 6370 4320 6730 {lab=D[6]}
N 4780 6370 4780 6730 {lab=D[7]}
N 5240 6370 5240 6730 {lab=D[8]}
N 5700 6370 5700 6730 {lab=D[9]}
N 6160 6370 6160 6730 {lab=D[10]}
N 6620 6370 6620 6730 {lab=D[11]}
N 7080 6370 7080 6730 {lab=D[12]}
N 7540 6370 7540 6730 {lab=D[13]}
N 8000 6370 8000 6730 {lab=D[14]}
N 8460 6370 8460 6730 {lab=D[15]}
N 1020 1000 1080 1000 {lab=B}
N 1480 1000 1540 1000 {lab=B}
N 1940 1000 2000 1000 {lab=B}
N 2400 1000 2460 1000 {lab=B}
N 2860 1000 2920 1000 {lab=B}
N 3320 1000 3380 1000 {lab=B}
N 3780 1000 3840 1000 {lab=B}
N 4240 1000 4300 1000 {lab=B}
N 4700 1000 4760 1000 {lab=B}
N 5160 1000 5220 1000 {lab=B}
N 5620 1000 5680 1000 {lab=B}
N 6080 1000 6140 1000 {lab=B}
N 6540 1000 6600 1000 {lab=B}
N 7000 1000 7060 1000 {lab=B}
N 7460 1000 7520 1000 {lab=B}
N 7920 1000 7980 1000 {lab=B}
N 8380 1000 8440 1000 {lab=B}
N 8840 1000 8900 1000 {lab=B}
N 1020 1360 1080 1360 {lab=B}
N 1480 1360 1540 1360 {lab=B}
N 1480 1330 1560 1330 {lab=D[0]}
N 1440 1240 1440 1360 {lab=G[0]}
N 80 1240 1440 1240 {lab=G[0]}
N 1480 1390 1480 1510 {lab=S[0]}
N 80 1510 1480 1510 {lab=S[0]}
N 1940 1360 2000 1360 {lab=B}
N 1940 1330 2020 1330 {lab=D[1]}
N 1900 1240 1900 1360 {lab=G[0]}
N 1440 1240 1900 1240 {lab=G[0]}
N 1940 1390 1940 1510 {lab=S[0]}
N 1480 1510 1940 1510 {lab=S[0]}
N 2400 1360 2460 1360 {lab=B}
N 2400 1330 2480 1330 {lab=D[2]}
N 2360 1240 2360 1360 {lab=G[0]}
N 1900 1240 2360 1240 {lab=G[0]}
N 2400 1390 2400 1510 {lab=S[0]}
N 1940 1510 2400 1510 {lab=S[0]}
N 2860 1360 2920 1360 {lab=B}
N 2860 1330 2940 1330 {lab=D[3]}
N 2820 1240 2820 1360 {lab=G[0]}
N 2360 1240 2820 1240 {lab=G[0]}
N 2860 1390 2860 1510 {lab=S[0]}
N 2400 1510 2860 1510 {lab=S[0]}
N 3320 1360 3380 1360 {lab=B}
N 3320 1330 3400 1330 {lab=D[4]}
N 3280 1240 3280 1360 {lab=G[0]}
N 2820 1240 3280 1240 {lab=G[0]}
N 3320 1390 3320 1510 {lab=S[0]}
N 2860 1510 3320 1510 {lab=S[0]}
N 3780 1360 3840 1360 {lab=B}
N 3780 1330 3860 1330 {lab=D[5]}
N 3740 1240 3740 1360 {lab=G[0]}
N 3280 1240 3740 1240 {lab=G[0]}
N 3780 1390 3780 1510 {lab=S[0]}
N 3320 1510 3780 1510 {lab=S[0]}
N 4240 1360 4300 1360 {lab=B}
N 4240 1330 4320 1330 {lab=D[6]}
N 4200 1240 4200 1360 {lab=G[0]}
N 3740 1240 4200 1240 {lab=G[0]}
N 4240 1390 4240 1510 {lab=S[0]}
N 3780 1510 4240 1510 {lab=S[0]}
N 4700 1360 4760 1360 {lab=B}
N 4700 1330 4780 1330 {lab=D[7]}
N 4660 1240 4660 1360 {lab=G[0]}
N 4200 1240 4660 1240 {lab=G[0]}
N 4700 1390 4700 1510 {lab=S[0]}
N 4240 1510 4700 1510 {lab=S[0]}
N 5160 1360 5220 1360 {lab=B}
N 5160 1330 5240 1330 {lab=D[8]}
N 5120 1240 5120 1360 {lab=G[0]}
N 4660 1240 5120 1240 {lab=G[0]}
N 5160 1390 5160 1510 {lab=S[0]}
N 4700 1510 5160 1510 {lab=S[0]}
N 5620 1360 5680 1360 {lab=B}
N 5620 1330 5700 1330 {lab=D[9]}
N 5580 1240 5580 1360 {lab=G[0]}
N 5120 1240 5580 1240 {lab=G[0]}
N 5620 1390 5620 1510 {lab=S[0]}
N 5160 1510 5620 1510 {lab=S[0]}
N 6080 1360 6140 1360 {lab=B}
N 6080 1330 6160 1330 {lab=D[10]}
N 6040 1240 6040 1360 {lab=G[0]}
N 5580 1240 6040 1240 {lab=G[0]}
N 6080 1390 6080 1510 {lab=S[0]}
N 5620 1510 6080 1510 {lab=S[0]}
N 6540 1360 6600 1360 {lab=B}
N 6540 1330 6620 1330 {lab=D[11]}
N 6500 1240 6500 1360 {lab=G[0]}
N 6040 1240 6500 1240 {lab=G[0]}
N 6540 1390 6540 1510 {lab=S[0]}
N 6080 1510 6540 1510 {lab=S[0]}
N 7000 1360 7060 1360 {lab=B}
N 7000 1330 7080 1330 {lab=D[12]}
N 6960 1240 6960 1360 {lab=G[0]}
N 6500 1240 6960 1240 {lab=G[0]}
N 7000 1390 7000 1510 {lab=S[0]}
N 6540 1510 7000 1510 {lab=S[0]}
N 7460 1360 7520 1360 {lab=B}
N 7460 1330 7540 1330 {lab=D[13]}
N 7420 1240 7420 1360 {lab=G[0]}
N 6960 1240 7420 1240 {lab=G[0]}
N 7460 1390 7460 1510 {lab=S[0]}
N 7000 1510 7460 1510 {lab=S[0]}
N 7920 1360 7980 1360 {lab=B}
N 7920 1330 8000 1330 {lab=D[14]}
N 7880 1240 7880 1360 {lab=G[0]}
N 7420 1240 7880 1240 {lab=G[0]}
N 7920 1390 7920 1510 {lab=S[0]}
N 7460 1510 7920 1510 {lab=S[0]}
N 8380 1360 8440 1360 {lab=B}
N 8380 1330 8460 1330 {lab=D[15]}
N 8340 1240 8340 1360 {lab=G[0]}
N 7880 1240 8340 1240 {lab=G[0]}
N 8380 1390 8380 1510 {lab=S[0]}
N 7920 1510 8380 1510 {lab=S[0]}
N 8840 1360 8900 1360 {lab=B}
N 1020 1720 1080 1720 {lab=B}
N 1480 1720 1540 1720 {lab=B}
N 1480 1690 1560 1690 {lab=D[0]}
N 1440 1600 1440 1720 {lab=G[1]}
N 80 1600 1440 1600 {lab=G[1]}
N 1480 1750 1480 1870 {lab=S[1]}
N 80 1870 1480 1870 {lab=S[1]}
N 1940 1720 2000 1720 {lab=B}
N 1940 1690 2020 1690 {lab=D[1]}
N 1900 1600 1900 1720 {lab=G[1]}
N 1440 1600 1900 1600 {lab=G[1]}
N 1940 1750 1940 1870 {lab=S[1]}
N 1480 1870 1940 1870 {lab=S[1]}
N 2400 1720 2460 1720 {lab=B}
N 2400 1690 2480 1690 {lab=D[2]}
N 2360 1600 2360 1720 {lab=G[1]}
N 1900 1600 2360 1600 {lab=G[1]}
N 2400 1750 2400 1870 {lab=S[1]}
N 1940 1870 2400 1870 {lab=S[1]}
N 2860 1720 2920 1720 {lab=B}
N 2860 1690 2940 1690 {lab=D[3]}
N 2820 1600 2820 1720 {lab=G[1]}
N 2360 1600 2820 1600 {lab=G[1]}
N 2860 1750 2860 1870 {lab=S[1]}
N 2400 1870 2860 1870 {lab=S[1]}
N 3320 1720 3380 1720 {lab=B}
N 3320 1690 3400 1690 {lab=D[4]}
N 3280 1600 3280 1720 {lab=G[1]}
N 2820 1600 3280 1600 {lab=G[1]}
N 3320 1750 3320 1870 {lab=S[1]}
N 2860 1870 3320 1870 {lab=S[1]}
N 3780 1720 3840 1720 {lab=B}
N 3780 1690 3860 1690 {lab=D[5]}
N 3740 1600 3740 1720 {lab=G[1]}
N 3280 1600 3740 1600 {lab=G[1]}
N 3780 1750 3780 1870 {lab=S[1]}
N 3320 1870 3780 1870 {lab=S[1]}
N 4240 1720 4300 1720 {lab=B}
N 4240 1690 4320 1690 {lab=D[6]}
N 4200 1600 4200 1720 {lab=G[1]}
N 3740 1600 4200 1600 {lab=G[1]}
N 4240 1750 4240 1870 {lab=S[1]}
N 3780 1870 4240 1870 {lab=S[1]}
N 4700 1720 4760 1720 {lab=B}
N 4700 1690 4780 1690 {lab=D[7]}
N 4660 1600 4660 1720 {lab=G[1]}
N 4200 1600 4660 1600 {lab=G[1]}
N 4700 1750 4700 1870 {lab=S[1]}
N 4240 1870 4700 1870 {lab=S[1]}
N 5160 1720 5220 1720 {lab=B}
N 5160 1690 5240 1690 {lab=D[8]}
N 5120 1600 5120 1720 {lab=G[1]}
N 4660 1600 5120 1600 {lab=G[1]}
N 5160 1750 5160 1870 {lab=S[1]}
N 4700 1870 5160 1870 {lab=S[1]}
N 5620 1720 5680 1720 {lab=B}
N 5620 1690 5700 1690 {lab=D[9]}
N 5580 1600 5580 1720 {lab=G[1]}
N 5120 1600 5580 1600 {lab=G[1]}
N 5620 1750 5620 1870 {lab=S[1]}
N 5160 1870 5620 1870 {lab=S[1]}
N 6080 1720 6140 1720 {lab=B}
N 6080 1690 6160 1690 {lab=D[10]}
N 6040 1600 6040 1720 {lab=G[1]}
N 5580 1600 6040 1600 {lab=G[1]}
N 6080 1750 6080 1870 {lab=S[1]}
N 5620 1870 6080 1870 {lab=S[1]}
N 6540 1720 6600 1720 {lab=B}
N 6540 1690 6620 1690 {lab=D[11]}
N 6500 1600 6500 1720 {lab=G[1]}
N 6040 1600 6500 1600 {lab=G[1]}
N 6540 1750 6540 1870 {lab=S[1]}
N 6080 1870 6540 1870 {lab=S[1]}
N 7000 1720 7060 1720 {lab=B}
N 7000 1690 7080 1690 {lab=D[12]}
N 6960 1600 6960 1720 {lab=G[1]}
N 6500 1600 6960 1600 {lab=G[1]}
N 7000 1750 7000 1870 {lab=S[1]}
N 6540 1870 7000 1870 {lab=S[1]}
N 7460 1720 7520 1720 {lab=B}
N 7460 1690 7540 1690 {lab=D[13]}
N 7420 1600 7420 1720 {lab=G[1]}
N 6960 1600 7420 1600 {lab=G[1]}
N 7460 1750 7460 1870 {lab=S[1]}
N 7000 1870 7460 1870 {lab=S[1]}
N 7920 1720 7980 1720 {lab=B}
N 7920 1690 8000 1690 {lab=D[14]}
N 7880 1600 7880 1720 {lab=G[1]}
N 7420 1600 7880 1600 {lab=G[1]}
N 7920 1750 7920 1870 {lab=S[1]}
N 7460 1870 7920 1870 {lab=S[1]}
N 8380 1720 8440 1720 {lab=B}
N 8380 1690 8460 1690 {lab=D[15]}
N 8340 1600 8340 1720 {lab=G[1]}
N 7880 1600 8340 1600 {lab=G[1]}
N 8380 1750 8380 1870 {lab=S[1]}
N 7920 1870 8380 1870 {lab=S[1]}
N 8840 1720 8900 1720 {lab=B}
N 1020 2080 1080 2080 {lab=B}
N 1480 2080 1540 2080 {lab=B}
N 1480 2050 1560 2050 {lab=D[0]}
N 1440 1960 1440 2080 {lab=G[2]}
N 80 1960 1440 1960 {lab=G[2]}
N 1480 2110 1480 2230 {lab=S[2]}
N 80 2230 1480 2230 {lab=S[2]}
N 1940 2080 2000 2080 {lab=B}
N 1940 2050 2020 2050 {lab=D[1]}
N 1900 1960 1900 2080 {lab=G[2]}
N 1440 1960 1900 1960 {lab=G[2]}
N 1940 2110 1940 2230 {lab=S[2]}
N 1480 2230 1940 2230 {lab=S[2]}
N 2400 2080 2460 2080 {lab=B}
N 2400 2050 2480 2050 {lab=D[2]}
N 2360 1960 2360 2080 {lab=G[2]}
N 1900 1960 2360 1960 {lab=G[2]}
N 2400 2110 2400 2230 {lab=S[2]}
N 1940 2230 2400 2230 {lab=S[2]}
N 2860 2080 2920 2080 {lab=B}
N 2860 2050 2940 2050 {lab=D[3]}
N 2820 1960 2820 2080 {lab=G[2]}
N 2360 1960 2820 1960 {lab=G[2]}
N 2860 2110 2860 2230 {lab=S[2]}
N 2400 2230 2860 2230 {lab=S[2]}
N 3320 2080 3380 2080 {lab=B}
N 3320 2050 3400 2050 {lab=D[4]}
N 3280 1960 3280 2080 {lab=G[2]}
N 2820 1960 3280 1960 {lab=G[2]}
N 3320 2110 3320 2230 {lab=S[2]}
N 2860 2230 3320 2230 {lab=S[2]}
N 3780 2080 3840 2080 {lab=B}
N 3780 2050 3860 2050 {lab=D[5]}
N 3740 1960 3740 2080 {lab=G[2]}
N 3280 1960 3740 1960 {lab=G[2]}
N 3780 2110 3780 2230 {lab=S[2]}
N 3320 2230 3780 2230 {lab=S[2]}
N 4240 2080 4300 2080 {lab=B}
N 4240 2050 4320 2050 {lab=D[6]}
N 4200 1960 4200 2080 {lab=G[2]}
N 3740 1960 4200 1960 {lab=G[2]}
N 4240 2110 4240 2230 {lab=S[2]}
N 3780 2230 4240 2230 {lab=S[2]}
N 4700 2080 4760 2080 {lab=B}
N 4700 2050 4780 2050 {lab=D[7]}
N 4660 1960 4660 2080 {lab=G[2]}
N 4200 1960 4660 1960 {lab=G[2]}
N 4700 2110 4700 2230 {lab=S[2]}
N 4240 2230 4700 2230 {lab=S[2]}
N 5160 2080 5220 2080 {lab=B}
N 5160 2050 5240 2050 {lab=D[8]}
N 5120 1960 5120 2080 {lab=G[2]}
N 4660 1960 5120 1960 {lab=G[2]}
N 5160 2110 5160 2230 {lab=S[2]}
N 4700 2230 5160 2230 {lab=S[2]}
N 5620 2080 5680 2080 {lab=B}
N 5620 2050 5700 2050 {lab=D[9]}
N 5580 1960 5580 2080 {lab=G[2]}
N 5120 1960 5580 1960 {lab=G[2]}
N 5620 2110 5620 2230 {lab=S[2]}
N 5160 2230 5620 2230 {lab=S[2]}
N 6080 2080 6140 2080 {lab=B}
N 6080 2050 6160 2050 {lab=D[10]}
N 6040 1960 6040 2080 {lab=G[2]}
N 5580 1960 6040 1960 {lab=G[2]}
N 6080 2110 6080 2230 {lab=S[2]}
N 5620 2230 6080 2230 {lab=S[2]}
N 6540 2080 6600 2080 {lab=B}
N 6540 2050 6620 2050 {lab=D[11]}
N 6500 1960 6500 2080 {lab=G[2]}
N 6040 1960 6500 1960 {lab=G[2]}
N 6540 2110 6540 2230 {lab=S[2]}
N 6080 2230 6540 2230 {lab=S[2]}
N 7000 2080 7060 2080 {lab=B}
N 7000 2050 7080 2050 {lab=D[12]}
N 6960 1960 6960 2080 {lab=G[2]}
N 6500 1960 6960 1960 {lab=G[2]}
N 7000 2110 7000 2230 {lab=S[2]}
N 6540 2230 7000 2230 {lab=S[2]}
N 7460 2080 7520 2080 {lab=B}
N 7460 2050 7540 2050 {lab=D[13]}
N 7420 1960 7420 2080 {lab=G[2]}
N 6960 1960 7420 1960 {lab=G[2]}
N 7460 2110 7460 2230 {lab=S[2]}
N 7000 2230 7460 2230 {lab=S[2]}
N 7920 2080 7980 2080 {lab=B}
N 7920 2050 8000 2050 {lab=D[14]}
N 7880 1960 7880 2080 {lab=G[2]}
N 7420 1960 7880 1960 {lab=G[2]}
N 7920 2110 7920 2230 {lab=S[2]}
N 7460 2230 7920 2230 {lab=S[2]}
N 8380 2080 8440 2080 {lab=B}
N 8380 2050 8460 2050 {lab=D[15]}
N 8340 1960 8340 2080 {lab=G[2]}
N 7880 1960 8340 1960 {lab=G[2]}
N 8380 2110 8380 2230 {lab=S[2]}
N 7920 2230 8380 2230 {lab=S[2]}
N 8840 2080 8900 2080 {lab=B}
N 1020 2440 1080 2440 {lab=B}
N 1480 2440 1540 2440 {lab=B}
N 1480 2410 1560 2410 {lab=D[0]}
N 1440 2320 1440 2440 {lab=G[3]}
N 80 2320 1440 2320 {lab=G[3]}
N 1480 2470 1480 2590 {lab=S[3]}
N 80 2590 1480 2590 {lab=S[3]}
N 1940 2440 2000 2440 {lab=B}
N 1940 2410 2020 2410 {lab=D[1]}
N 1900 2320 1900 2440 {lab=G[3]}
N 1440 2320 1900 2320 {lab=G[3]}
N 1940 2470 1940 2590 {lab=S[3]}
N 1480 2590 1940 2590 {lab=S[3]}
N 2400 2440 2460 2440 {lab=B}
N 2400 2410 2480 2410 {lab=D[2]}
N 2360 2320 2360 2440 {lab=G[3]}
N 1900 2320 2360 2320 {lab=G[3]}
N 2400 2470 2400 2590 {lab=S[3]}
N 1940 2590 2400 2590 {lab=S[3]}
N 2860 2440 2920 2440 {lab=B}
N 2860 2410 2940 2410 {lab=D[3]}
N 2820 2320 2820 2440 {lab=G[3]}
N 2360 2320 2820 2320 {lab=G[3]}
N 2860 2470 2860 2590 {lab=S[3]}
N 2400 2590 2860 2590 {lab=S[3]}
N 3320 2440 3380 2440 {lab=B}
N 3320 2410 3400 2410 {lab=D[4]}
N 3280 2320 3280 2440 {lab=G[3]}
N 2820 2320 3280 2320 {lab=G[3]}
N 3320 2470 3320 2590 {lab=S[3]}
N 2860 2590 3320 2590 {lab=S[3]}
N 3780 2440 3840 2440 {lab=B}
N 3780 2410 3860 2410 {lab=D[5]}
N 3740 2320 3740 2440 {lab=G[3]}
N 3280 2320 3740 2320 {lab=G[3]}
N 3780 2470 3780 2590 {lab=S[3]}
N 3320 2590 3780 2590 {lab=S[3]}
N 4240 2440 4300 2440 {lab=B}
N 4240 2410 4320 2410 {lab=D[6]}
N 4200 2320 4200 2440 {lab=G[3]}
N 3740 2320 4200 2320 {lab=G[3]}
N 4240 2470 4240 2590 {lab=S[3]}
N 3780 2590 4240 2590 {lab=S[3]}
N 4700 2440 4760 2440 {lab=B}
N 4700 2410 4780 2410 {lab=D[7]}
N 4660 2320 4660 2440 {lab=G[3]}
N 4200 2320 4660 2320 {lab=G[3]}
N 4700 2470 4700 2590 {lab=S[3]}
N 4240 2590 4700 2590 {lab=S[3]}
N 5160 2440 5220 2440 {lab=B}
N 5160 2410 5240 2410 {lab=D[8]}
N 5120 2320 5120 2440 {lab=G[3]}
N 4660 2320 5120 2320 {lab=G[3]}
N 5160 2470 5160 2590 {lab=S[3]}
N 4700 2590 5160 2590 {lab=S[3]}
N 5620 2440 5680 2440 {lab=B}
N 5620 2410 5700 2410 {lab=D[9]}
N 5580 2320 5580 2440 {lab=G[3]}
N 5120 2320 5580 2320 {lab=G[3]}
N 5620 2470 5620 2590 {lab=S[3]}
N 5160 2590 5620 2590 {lab=S[3]}
N 6080 2440 6140 2440 {lab=B}
N 6080 2410 6160 2410 {lab=D[10]}
N 6040 2320 6040 2440 {lab=G[3]}
N 5580 2320 6040 2320 {lab=G[3]}
N 6080 2470 6080 2590 {lab=S[3]}
N 5620 2590 6080 2590 {lab=S[3]}
N 6540 2440 6600 2440 {lab=B}
N 6540 2410 6620 2410 {lab=D[11]}
N 6500 2320 6500 2440 {lab=G[3]}
N 6040 2320 6500 2320 {lab=G[3]}
N 6540 2470 6540 2590 {lab=S[3]}
N 6080 2590 6540 2590 {lab=S[3]}
N 7000 2440 7060 2440 {lab=B}
N 7000 2410 7080 2410 {lab=D[12]}
N 6960 2320 6960 2440 {lab=G[3]}
N 6500 2320 6960 2320 {lab=G[3]}
N 7000 2470 7000 2590 {lab=S[3]}
N 6540 2590 7000 2590 {lab=S[3]}
N 7460 2440 7520 2440 {lab=B}
N 7460 2410 7540 2410 {lab=D[13]}
N 7420 2320 7420 2440 {lab=G[3]}
N 6960 2320 7420 2320 {lab=G[3]}
N 7460 2470 7460 2590 {lab=S[3]}
N 7000 2590 7460 2590 {lab=S[3]}
N 7920 2440 7980 2440 {lab=B}
N 7920 2410 8000 2410 {lab=D[14]}
N 7880 2320 7880 2440 {lab=G[3]}
N 7420 2320 7880 2320 {lab=G[3]}
N 7920 2470 7920 2590 {lab=S[3]}
N 7460 2590 7920 2590 {lab=S[3]}
N 8380 2440 8440 2440 {lab=B}
N 8380 2410 8460 2410 {lab=D[15]}
N 8340 2320 8340 2440 {lab=G[3]}
N 7880 2320 8340 2320 {lab=G[3]}
N 8380 2470 8380 2590 {lab=S[3]}
N 7920 2590 8380 2590 {lab=S[3]}
N 8840 2440 8900 2440 {lab=B}
N 1020 2800 1080 2800 {lab=B}
N 1480 2800 1540 2800 {lab=B}
N 1480 2770 1560 2770 {lab=D[0]}
N 1440 2680 1440 2800 {lab=G[4]}
N 80 2680 1440 2680 {lab=G[4]}
N 1480 2830 1480 2950 {lab=S[4]}
N 80 2950 1480 2950 {lab=S[4]}
N 1940 2800 2000 2800 {lab=B}
N 1940 2770 2020 2770 {lab=D[1]}
N 1900 2680 1900 2800 {lab=G[4]}
N 1440 2680 1900 2680 {lab=G[4]}
N 1940 2830 1940 2950 {lab=S[4]}
N 1480 2950 1940 2950 {lab=S[4]}
N 2400 2800 2460 2800 {lab=B}
N 2400 2770 2480 2770 {lab=D[2]}
N 2360 2680 2360 2800 {lab=G[4]}
N 1900 2680 2360 2680 {lab=G[4]}
N 2400 2830 2400 2950 {lab=S[4]}
N 1940 2950 2400 2950 {lab=S[4]}
N 2860 2800 2920 2800 {lab=B}
N 2860 2770 2940 2770 {lab=D[3]}
N 2820 2680 2820 2800 {lab=G[4]}
N 2360 2680 2820 2680 {lab=G[4]}
N 2860 2830 2860 2950 {lab=S[4]}
N 2400 2950 2860 2950 {lab=S[4]}
N 3320 2800 3380 2800 {lab=B}
N 3320 2770 3400 2770 {lab=D[4]}
N 3280 2680 3280 2800 {lab=G[4]}
N 2820 2680 3280 2680 {lab=G[4]}
N 3320 2830 3320 2950 {lab=S[4]}
N 2860 2950 3320 2950 {lab=S[4]}
N 3780 2800 3840 2800 {lab=B}
N 3780 2770 3860 2770 {lab=D[5]}
N 3740 2680 3740 2800 {lab=G[4]}
N 3280 2680 3740 2680 {lab=G[4]}
N 3780 2830 3780 2950 {lab=S[4]}
N 3320 2950 3780 2950 {lab=S[4]}
N 4240 2800 4300 2800 {lab=B}
N 4240 2770 4320 2770 {lab=D[6]}
N 4200 2680 4200 2800 {lab=G[4]}
N 3740 2680 4200 2680 {lab=G[4]}
N 4240 2830 4240 2950 {lab=S[4]}
N 3780 2950 4240 2950 {lab=S[4]}
N 4700 2800 4760 2800 {lab=B}
N 4700 2770 4780 2770 {lab=D[7]}
N 4660 2680 4660 2800 {lab=G[4]}
N 4200 2680 4660 2680 {lab=G[4]}
N 4700 2830 4700 2950 {lab=S[4]}
N 4240 2950 4700 2950 {lab=S[4]}
N 5160 2800 5220 2800 {lab=B}
N 5160 2770 5240 2770 {lab=D[8]}
N 5120 2680 5120 2800 {lab=G[4]}
N 4660 2680 5120 2680 {lab=G[4]}
N 5160 2830 5160 2950 {lab=S[4]}
N 4700 2950 5160 2950 {lab=S[4]}
N 5620 2800 5680 2800 {lab=B}
N 5620 2770 5700 2770 {lab=D[9]}
N 5580 2680 5580 2800 {lab=G[4]}
N 5120 2680 5580 2680 {lab=G[4]}
N 5620 2830 5620 2950 {lab=S[4]}
N 5160 2950 5620 2950 {lab=S[4]}
N 6080 2800 6140 2800 {lab=B}
N 6080 2770 6160 2770 {lab=D[10]}
N 6040 2680 6040 2800 {lab=G[4]}
N 5580 2680 6040 2680 {lab=G[4]}
N 6080 2830 6080 2950 {lab=S[4]}
N 5620 2950 6080 2950 {lab=S[4]}
N 6540 2800 6600 2800 {lab=B}
N 6540 2770 6620 2770 {lab=D[11]}
N 6500 2680 6500 2800 {lab=G[4]}
N 6040 2680 6500 2680 {lab=G[4]}
N 6540 2830 6540 2950 {lab=S[4]}
N 6080 2950 6540 2950 {lab=S[4]}
N 7000 2800 7060 2800 {lab=B}
N 7000 2770 7080 2770 {lab=D[12]}
N 6960 2680 6960 2800 {lab=G[4]}
N 6500 2680 6960 2680 {lab=G[4]}
N 7000 2830 7000 2950 {lab=S[4]}
N 6540 2950 7000 2950 {lab=S[4]}
N 7460 2800 7520 2800 {lab=B}
N 7460 2770 7540 2770 {lab=D[13]}
N 7420 2680 7420 2800 {lab=G[4]}
N 6960 2680 7420 2680 {lab=G[4]}
N 7460 2830 7460 2950 {lab=S[4]}
N 7000 2950 7460 2950 {lab=S[4]}
N 7920 2800 7980 2800 {lab=B}
N 7920 2770 8000 2770 {lab=D[14]}
N 7880 2680 7880 2800 {lab=G[4]}
N 7420 2680 7880 2680 {lab=G[4]}
N 7920 2830 7920 2950 {lab=S[4]}
N 7460 2950 7920 2950 {lab=S[4]}
N 8380 2800 8440 2800 {lab=B}
N 8380 2770 8460 2770 {lab=D[15]}
N 8340 2680 8340 2800 {lab=G[4]}
N 7880 2680 8340 2680 {lab=G[4]}
N 8380 2830 8380 2950 {lab=S[4]}
N 7920 2950 8380 2950 {lab=S[4]}
N 8840 2800 8900 2800 {lab=B}
N 1020 3160 1080 3160 {lab=B}
N 1480 3160 1540 3160 {lab=B}
N 1480 3130 1560 3130 {lab=D[0]}
N 1440 3040 1440 3160 {lab=G[5]}
N 80 3040 1440 3040 {lab=G[5]}
N 1480 3190 1480 3310 {lab=S[5]}
N 80 3310 1480 3310 {lab=S[5]}
N 1940 3160 2000 3160 {lab=B}
N 1940 3130 2020 3130 {lab=D[1]}
N 1900 3040 1900 3160 {lab=G[5]}
N 1440 3040 1900 3040 {lab=G[5]}
N 1940 3190 1940 3310 {lab=S[5]}
N 1480 3310 1940 3310 {lab=S[5]}
N 2400 3160 2460 3160 {lab=B}
N 2400 3130 2480 3130 {lab=D[2]}
N 2360 3040 2360 3160 {lab=G[5]}
N 1900 3040 2360 3040 {lab=G[5]}
N 2400 3190 2400 3310 {lab=S[5]}
N 1940 3310 2400 3310 {lab=S[5]}
N 2860 3160 2920 3160 {lab=B}
N 2860 3130 2940 3130 {lab=D[3]}
N 2820 3040 2820 3160 {lab=G[5]}
N 2360 3040 2820 3040 {lab=G[5]}
N 2860 3190 2860 3310 {lab=S[5]}
N 2400 3310 2860 3310 {lab=S[5]}
N 3320 3160 3380 3160 {lab=B}
N 3320 3130 3400 3130 {lab=D[4]}
N 3280 3040 3280 3160 {lab=G[5]}
N 2820 3040 3280 3040 {lab=G[5]}
N 3320 3190 3320 3310 {lab=S[5]}
N 2860 3310 3320 3310 {lab=S[5]}
N 3780 3160 3840 3160 {lab=B}
N 3780 3130 3860 3130 {lab=D[5]}
N 3740 3040 3740 3160 {lab=G[5]}
N 3280 3040 3740 3040 {lab=G[5]}
N 3780 3190 3780 3310 {lab=S[5]}
N 3320 3310 3780 3310 {lab=S[5]}
N 4240 3160 4300 3160 {lab=B}
N 4240 3130 4320 3130 {lab=D[6]}
N 4200 3040 4200 3160 {lab=G[5]}
N 3740 3040 4200 3040 {lab=G[5]}
N 4240 3190 4240 3310 {lab=S[5]}
N 3780 3310 4240 3310 {lab=S[5]}
N 4700 3160 4760 3160 {lab=B}
N 4700 3130 4780 3130 {lab=D[7]}
N 4660 3040 4660 3160 {lab=G[5]}
N 4200 3040 4660 3040 {lab=G[5]}
N 4700 3190 4700 3310 {lab=S[5]}
N 4240 3310 4700 3310 {lab=S[5]}
N 5160 3160 5220 3160 {lab=B}
N 5160 3130 5240 3130 {lab=D[8]}
N 5120 3040 5120 3160 {lab=G[5]}
N 4660 3040 5120 3040 {lab=G[5]}
N 5160 3190 5160 3310 {lab=S[5]}
N 4700 3310 5160 3310 {lab=S[5]}
N 5620 3160 5680 3160 {lab=B}
N 5620 3130 5700 3130 {lab=D[9]}
N 5580 3040 5580 3160 {lab=G[5]}
N 5120 3040 5580 3040 {lab=G[5]}
N 5620 3190 5620 3310 {lab=S[5]}
N 5160 3310 5620 3310 {lab=S[5]}
N 6080 3160 6140 3160 {lab=B}
N 6080 3130 6160 3130 {lab=D[10]}
N 6040 3040 6040 3160 {lab=G[5]}
N 5580 3040 6040 3040 {lab=G[5]}
N 6080 3190 6080 3310 {lab=S[5]}
N 5620 3310 6080 3310 {lab=S[5]}
N 6540 3160 6600 3160 {lab=B}
N 6540 3130 6620 3130 {lab=D[11]}
N 6500 3040 6500 3160 {lab=G[5]}
N 6040 3040 6500 3040 {lab=G[5]}
N 6540 3190 6540 3310 {lab=S[5]}
N 6080 3310 6540 3310 {lab=S[5]}
N 7000 3160 7060 3160 {lab=B}
N 7000 3130 7080 3130 {lab=D[12]}
N 6960 3040 6960 3160 {lab=G[5]}
N 6500 3040 6960 3040 {lab=G[5]}
N 7000 3190 7000 3310 {lab=S[5]}
N 6540 3310 7000 3310 {lab=S[5]}
N 7460 3160 7520 3160 {lab=B}
N 7460 3130 7540 3130 {lab=D[13]}
N 7420 3040 7420 3160 {lab=G[5]}
N 6960 3040 7420 3040 {lab=G[5]}
N 7460 3190 7460 3310 {lab=S[5]}
N 7000 3310 7460 3310 {lab=S[5]}
N 7920 3160 7980 3160 {lab=B}
N 7920 3130 8000 3130 {lab=D[14]}
N 7880 3040 7880 3160 {lab=G[5]}
N 7420 3040 7880 3040 {lab=G[5]}
N 7920 3190 7920 3310 {lab=S[5]}
N 7460 3310 7920 3310 {lab=S[5]}
N 8380 3160 8440 3160 {lab=B}
N 8380 3130 8460 3130 {lab=D[15]}
N 8340 3040 8340 3160 {lab=G[5]}
N 7880 3040 8340 3040 {lab=G[5]}
N 8380 3190 8380 3310 {lab=S[5]}
N 7920 3310 8380 3310 {lab=S[5]}
N 8840 3160 8900 3160 {lab=B}
N 1020 3520 1080 3520 {lab=B}
N 1480 3520 1540 3520 {lab=B}
N 1480 3490 1560 3490 {lab=D[0]}
N 1440 3400 1440 3520 {lab=G[6]}
N 80 3400 1440 3400 {lab=G[6]}
N 1480 3550 1480 3670 {lab=S[6]}
N 80 3670 1480 3670 {lab=S[6]}
N 1940 3520 2000 3520 {lab=B}
N 1940 3490 2020 3490 {lab=D[1]}
N 1900 3400 1900 3520 {lab=G[6]}
N 1440 3400 1900 3400 {lab=G[6]}
N 1940 3550 1940 3670 {lab=S[6]}
N 1480 3670 1940 3670 {lab=S[6]}
N 2400 3520 2460 3520 {lab=B}
N 2400 3490 2480 3490 {lab=D[2]}
N 2360 3400 2360 3520 {lab=G[6]}
N 1900 3400 2360 3400 {lab=G[6]}
N 2400 3550 2400 3670 {lab=S[6]}
N 1940 3670 2400 3670 {lab=S[6]}
N 2860 3520 2920 3520 {lab=B}
N 2860 3490 2940 3490 {lab=D[3]}
N 2820 3400 2820 3520 {lab=G[6]}
N 2360 3400 2820 3400 {lab=G[6]}
N 2860 3550 2860 3670 {lab=S[6]}
N 2400 3670 2860 3670 {lab=S[6]}
N 3320 3520 3380 3520 {lab=B}
N 3320 3490 3400 3490 {lab=D[4]}
N 3280 3400 3280 3520 {lab=G[6]}
N 2820 3400 3280 3400 {lab=G[6]}
N 3320 3550 3320 3670 {lab=S[6]}
N 2860 3670 3320 3670 {lab=S[6]}
N 3780 3520 3840 3520 {lab=B}
N 3780 3490 3860 3490 {lab=D[5]}
N 3740 3400 3740 3520 {lab=G[6]}
N 3280 3400 3740 3400 {lab=G[6]}
N 3780 3550 3780 3670 {lab=S[6]}
N 3320 3670 3780 3670 {lab=S[6]}
N 4240 3520 4300 3520 {lab=B}
N 4240 3490 4320 3490 {lab=D[6]}
N 4200 3400 4200 3520 {lab=G[6]}
N 3740 3400 4200 3400 {lab=G[6]}
N 4240 3550 4240 3670 {lab=S[6]}
N 3780 3670 4240 3670 {lab=S[6]}
N 4700 3520 4760 3520 {lab=B}
N 4700 3490 4780 3490 {lab=D[7]}
N 4660 3400 4660 3520 {lab=G[6]}
N 4200 3400 4660 3400 {lab=G[6]}
N 4700 3550 4700 3670 {lab=S[6]}
N 4240 3670 4700 3670 {lab=S[6]}
N 5160 3520 5220 3520 {lab=B}
N 5160 3490 5240 3490 {lab=D[8]}
N 5120 3400 5120 3520 {lab=G[6]}
N 4660 3400 5120 3400 {lab=G[6]}
N 5160 3550 5160 3670 {lab=S[6]}
N 4700 3670 5160 3670 {lab=S[6]}
N 5620 3520 5680 3520 {lab=B}
N 5620 3490 5700 3490 {lab=D[9]}
N 5580 3400 5580 3520 {lab=G[6]}
N 5120 3400 5580 3400 {lab=G[6]}
N 5620 3550 5620 3670 {lab=S[6]}
N 5160 3670 5620 3670 {lab=S[6]}
N 6080 3520 6140 3520 {lab=B}
N 6080 3490 6160 3490 {lab=D[10]}
N 6040 3400 6040 3520 {lab=G[6]}
N 5580 3400 6040 3400 {lab=G[6]}
N 6080 3550 6080 3670 {lab=S[6]}
N 5620 3670 6080 3670 {lab=S[6]}
N 6540 3520 6600 3520 {lab=B}
N 6540 3490 6620 3490 {lab=D[11]}
N 6500 3400 6500 3520 {lab=G[6]}
N 6040 3400 6500 3400 {lab=G[6]}
N 6540 3550 6540 3670 {lab=S[6]}
N 6080 3670 6540 3670 {lab=S[6]}
N 7000 3520 7060 3520 {lab=B}
N 7000 3490 7080 3490 {lab=D[12]}
N 6960 3400 6960 3520 {lab=G[6]}
N 6500 3400 6960 3400 {lab=G[6]}
N 7000 3550 7000 3670 {lab=S[6]}
N 6540 3670 7000 3670 {lab=S[6]}
N 7460 3520 7520 3520 {lab=B}
N 7460 3490 7540 3490 {lab=D[13]}
N 7420 3400 7420 3520 {lab=G[6]}
N 6960 3400 7420 3400 {lab=G[6]}
N 7460 3550 7460 3670 {lab=S[6]}
N 7000 3670 7460 3670 {lab=S[6]}
N 7920 3520 7980 3520 {lab=B}
N 7920 3490 8000 3490 {lab=D[14]}
N 7880 3400 7880 3520 {lab=G[6]}
N 7420 3400 7880 3400 {lab=G[6]}
N 7920 3550 7920 3670 {lab=S[6]}
N 7460 3670 7920 3670 {lab=S[6]}
N 8380 3520 8440 3520 {lab=B}
N 8380 3490 8460 3490 {lab=D[15]}
N 8340 3400 8340 3520 {lab=G[6]}
N 7880 3400 8340 3400 {lab=G[6]}
N 8380 3550 8380 3670 {lab=S[6]}
N 7920 3670 8380 3670 {lab=S[6]}
N 8840 3520 8900 3520 {lab=B}
N 1020 3880 1080 3880 {lab=B}
N 1480 3880 1540 3880 {lab=B}
N 1480 3850 1560 3850 {lab=D[0]}
N 1440 3760 1440 3880 {lab=G[7]}
N 80 3760 1440 3760 {lab=G[7]}
N 1480 3910 1480 4030 {lab=S[7]}
N 80 4030 1480 4030 {lab=S[7]}
N 1940 3880 2000 3880 {lab=B}
N 1940 3850 2020 3850 {lab=D[1]}
N 1900 3760 1900 3880 {lab=G[7]}
N 1440 3760 1900 3760 {lab=G[7]}
N 1940 3910 1940 4030 {lab=S[7]}
N 1480 4030 1940 4030 {lab=S[7]}
N 2400 3880 2460 3880 {lab=B}
N 2400 3850 2480 3850 {lab=D[2]}
N 2360 3760 2360 3880 {lab=G[7]}
N 1900 3760 2360 3760 {lab=G[7]}
N 2400 3910 2400 4030 {lab=S[7]}
N 1940 4030 2400 4030 {lab=S[7]}
N 2860 3880 2920 3880 {lab=B}
N 2860 3850 2940 3850 {lab=D[3]}
N 2820 3760 2820 3880 {lab=G[7]}
N 2360 3760 2820 3760 {lab=G[7]}
N 2860 3910 2860 4030 {lab=S[7]}
N 2400 4030 2860 4030 {lab=S[7]}
N 3320 3880 3380 3880 {lab=B}
N 3320 3850 3400 3850 {lab=D[4]}
N 3280 3760 3280 3880 {lab=G[7]}
N 2820 3760 3280 3760 {lab=G[7]}
N 3320 3910 3320 4030 {lab=S[7]}
N 2860 4030 3320 4030 {lab=S[7]}
N 3780 3880 3840 3880 {lab=B}
N 3780 3850 3860 3850 {lab=D[5]}
N 3740 3760 3740 3880 {lab=G[7]}
N 3280 3760 3740 3760 {lab=G[7]}
N 3780 3910 3780 4030 {lab=S[7]}
N 3320 4030 3780 4030 {lab=S[7]}
N 4240 3880 4300 3880 {lab=B}
N 4240 3850 4320 3850 {lab=D[6]}
N 4200 3760 4200 3880 {lab=G[7]}
N 3740 3760 4200 3760 {lab=G[7]}
N 4240 3910 4240 4030 {lab=S[7]}
N 3780 4030 4240 4030 {lab=S[7]}
N 4700 3880 4760 3880 {lab=B}
N 4700 3850 4780 3850 {lab=D[7]}
N 4660 3760 4660 3880 {lab=G[7]}
N 4200 3760 4660 3760 {lab=G[7]}
N 4700 3910 4700 4030 {lab=S[7]}
N 4240 4030 4700 4030 {lab=S[7]}
N 5160 3880 5220 3880 {lab=B}
N 5160 3850 5240 3850 {lab=D[8]}
N 5120 3760 5120 3880 {lab=G[7]}
N 4660 3760 5120 3760 {lab=G[7]}
N 5160 3910 5160 4030 {lab=S[7]}
N 4700 4030 5160 4030 {lab=S[7]}
N 5620 3880 5680 3880 {lab=B}
N 5620 3850 5700 3850 {lab=D[9]}
N 5580 3760 5580 3880 {lab=G[7]}
N 5120 3760 5580 3760 {lab=G[7]}
N 5620 3910 5620 4030 {lab=S[7]}
N 5160 4030 5620 4030 {lab=S[7]}
N 6080 3880 6140 3880 {lab=B}
N 6080 3850 6160 3850 {lab=D[10]}
N 6040 3760 6040 3880 {lab=G[7]}
N 5580 3760 6040 3760 {lab=G[7]}
N 6080 3910 6080 4030 {lab=S[7]}
N 5620 4030 6080 4030 {lab=S[7]}
N 6540 3880 6600 3880 {lab=B}
N 6540 3850 6620 3850 {lab=D[11]}
N 6500 3760 6500 3880 {lab=G[7]}
N 6040 3760 6500 3760 {lab=G[7]}
N 6540 3910 6540 4030 {lab=S[7]}
N 6080 4030 6540 4030 {lab=S[7]}
N 7000 3880 7060 3880 {lab=B}
N 7000 3850 7080 3850 {lab=D[12]}
N 6960 3760 6960 3880 {lab=G[7]}
N 6500 3760 6960 3760 {lab=G[7]}
N 7000 3910 7000 4030 {lab=S[7]}
N 6540 4030 7000 4030 {lab=S[7]}
N 7460 3880 7520 3880 {lab=B}
N 7460 3850 7540 3850 {lab=D[13]}
N 7420 3760 7420 3880 {lab=G[7]}
N 6960 3760 7420 3760 {lab=G[7]}
N 7460 3910 7460 4030 {lab=S[7]}
N 7000 4030 7460 4030 {lab=S[7]}
N 7920 3880 7980 3880 {lab=B}
N 7920 3850 8000 3850 {lab=D[14]}
N 7880 3760 7880 3880 {lab=G[7]}
N 7420 3760 7880 3760 {lab=G[7]}
N 7920 3910 7920 4030 {lab=S[7]}
N 7460 4030 7920 4030 {lab=S[7]}
N 8380 3880 8440 3880 {lab=B}
N 8380 3850 8460 3850 {lab=D[15]}
N 8340 3760 8340 3880 {lab=G[7]}
N 7880 3760 8340 3760 {lab=G[7]}
N 8380 3910 8380 4030 {lab=S[7]}
N 7920 4030 8380 4030 {lab=S[7]}
N 8840 3880 8900 3880 {lab=B}
N 1020 4240 1080 4240 {lab=B}
N 1480 4240 1540 4240 {lab=B}
N 1480 4210 1560 4210 {lab=D[0]}
N 1440 4120 1440 4240 {lab=G[8]}
N 80 4120 1440 4120 {lab=G[8]}
N 1480 4270 1480 4390 {lab=S[8]}
N 80 4390 1480 4390 {lab=S[8]}
N 1940 4240 2000 4240 {lab=B}
N 1940 4210 2020 4210 {lab=D[1]}
N 1900 4120 1900 4240 {lab=G[8]}
N 1440 4120 1900 4120 {lab=G[8]}
N 1940 4270 1940 4390 {lab=S[8]}
N 1480 4390 1940 4390 {lab=S[8]}
N 2400 4240 2460 4240 {lab=B}
N 2400 4210 2480 4210 {lab=D[2]}
N 2360 4120 2360 4240 {lab=G[8]}
N 1900 4120 2360 4120 {lab=G[8]}
N 2400 4270 2400 4390 {lab=S[8]}
N 1940 4390 2400 4390 {lab=S[8]}
N 2860 4240 2920 4240 {lab=B}
N 2860 4210 2940 4210 {lab=D[3]}
N 2820 4120 2820 4240 {lab=G[8]}
N 2360 4120 2820 4120 {lab=G[8]}
N 2860 4270 2860 4390 {lab=S[8]}
N 2400 4390 2860 4390 {lab=S[8]}
N 3320 4240 3380 4240 {lab=B}
N 3320 4210 3400 4210 {lab=D[4]}
N 3280 4120 3280 4240 {lab=G[8]}
N 2820 4120 3280 4120 {lab=G[8]}
N 3320 4270 3320 4390 {lab=S[8]}
N 2860 4390 3320 4390 {lab=S[8]}
N 3780 4240 3840 4240 {lab=B}
N 3780 4210 3860 4210 {lab=D[5]}
N 3740 4120 3740 4240 {lab=G[8]}
N 3280 4120 3740 4120 {lab=G[8]}
N 3780 4270 3780 4390 {lab=S[8]}
N 3320 4390 3780 4390 {lab=S[8]}
N 4240 4240 4300 4240 {lab=B}
N 4240 4210 4320 4210 {lab=D[6]}
N 4200 4120 4200 4240 {lab=G[8]}
N 3740 4120 4200 4120 {lab=G[8]}
N 4240 4270 4240 4390 {lab=S[8]}
N 3780 4390 4240 4390 {lab=S[8]}
N 4700 4240 4760 4240 {lab=B}
N 4700 4210 4780 4210 {lab=D[7]}
N 4660 4120 4660 4240 {lab=G[8]}
N 4200 4120 4660 4120 {lab=G[8]}
N 4700 4270 4700 4390 {lab=S[8]}
N 4240 4390 4700 4390 {lab=S[8]}
N 5160 4240 5220 4240 {lab=B}
N 5160 4210 5240 4210 {lab=D[8]}
N 5120 4120 5120 4240 {lab=G[8]}
N 4660 4120 5120 4120 {lab=G[8]}
N 5160 4270 5160 4390 {lab=S[8]}
N 4700 4390 5160 4390 {lab=S[8]}
N 5620 4240 5680 4240 {lab=B}
N 5620 4210 5700 4210 {lab=D[9]}
N 5580 4120 5580 4240 {lab=G[8]}
N 5120 4120 5580 4120 {lab=G[8]}
N 5620 4270 5620 4390 {lab=S[8]}
N 5160 4390 5620 4390 {lab=S[8]}
N 6080 4240 6140 4240 {lab=B}
N 6080 4210 6160 4210 {lab=D[10]}
N 6040 4120 6040 4240 {lab=G[8]}
N 5580 4120 6040 4120 {lab=G[8]}
N 6080 4270 6080 4390 {lab=S[8]}
N 5620 4390 6080 4390 {lab=S[8]}
N 6540 4240 6600 4240 {lab=B}
N 6540 4210 6620 4210 {lab=D[11]}
N 6500 4120 6500 4240 {lab=G[8]}
N 6040 4120 6500 4120 {lab=G[8]}
N 6540 4270 6540 4390 {lab=S[8]}
N 6080 4390 6540 4390 {lab=S[8]}
N 7000 4240 7060 4240 {lab=B}
N 7000 4210 7080 4210 {lab=D[12]}
N 6960 4120 6960 4240 {lab=G[8]}
N 6500 4120 6960 4120 {lab=G[8]}
N 7000 4270 7000 4390 {lab=S[8]}
N 6540 4390 7000 4390 {lab=S[8]}
N 7460 4240 7520 4240 {lab=B}
N 7460 4210 7540 4210 {lab=D[13]}
N 7420 4120 7420 4240 {lab=G[8]}
N 6960 4120 7420 4120 {lab=G[8]}
N 7460 4270 7460 4390 {lab=S[8]}
N 7000 4390 7460 4390 {lab=S[8]}
N 7920 4240 7980 4240 {lab=B}
N 7920 4210 8000 4210 {lab=D[14]}
N 7880 4120 7880 4240 {lab=G[8]}
N 7420 4120 7880 4120 {lab=G[8]}
N 7920 4270 7920 4390 {lab=S[8]}
N 7460 4390 7920 4390 {lab=S[8]}
N 8380 4240 8440 4240 {lab=B}
N 8380 4210 8460 4210 {lab=D[15]}
N 8340 4120 8340 4240 {lab=G[8]}
N 7880 4120 8340 4120 {lab=G[8]}
N 8380 4270 8380 4390 {lab=S[8]}
N 7920 4390 8380 4390 {lab=S[8]}
N 8840 4240 8900 4240 {lab=B}
N 1020 4600 1080 4600 {lab=B}
N 1480 4600 1540 4600 {lab=B}
N 1480 4570 1560 4570 {lab=D[0]}
N 1440 4480 1440 4600 {lab=G[9]}
N 80 4480 1440 4480 {lab=G[9]}
N 1480 4630 1480 4750 {lab=S[9]}
N 80 4750 1480 4750 {lab=S[9]}
N 1940 4600 2000 4600 {lab=B}
N 1940 4570 2020 4570 {lab=D[1]}
N 1900 4480 1900 4600 {lab=G[9]}
N 1440 4480 1900 4480 {lab=G[9]}
N 1940 4630 1940 4750 {lab=S[9]}
N 1480 4750 1940 4750 {lab=S[9]}
N 2400 4600 2460 4600 {lab=B}
N 2400 4570 2480 4570 {lab=D[2]}
N 2360 4480 2360 4600 {lab=G[9]}
N 1900 4480 2360 4480 {lab=G[9]}
N 2400 4630 2400 4750 {lab=S[9]}
N 1940 4750 2400 4750 {lab=S[9]}
N 2860 4600 2920 4600 {lab=B}
N 2860 4570 2940 4570 {lab=D[3]}
N 2820 4480 2820 4600 {lab=G[9]}
N 2360 4480 2820 4480 {lab=G[9]}
N 2860 4630 2860 4750 {lab=S[9]}
N 2400 4750 2860 4750 {lab=S[9]}
N 3320 4600 3380 4600 {lab=B}
N 3320 4570 3400 4570 {lab=D[4]}
N 3280 4480 3280 4600 {lab=G[9]}
N 2820 4480 3280 4480 {lab=G[9]}
N 3320 4630 3320 4750 {lab=S[9]}
N 2860 4750 3320 4750 {lab=S[9]}
N 3780 4600 3840 4600 {lab=B}
N 3780 4570 3860 4570 {lab=D[5]}
N 3740 4480 3740 4600 {lab=G[9]}
N 3280 4480 3740 4480 {lab=G[9]}
N 3780 4630 3780 4750 {lab=S[9]}
N 3320 4750 3780 4750 {lab=S[9]}
N 4240 4600 4300 4600 {lab=B}
N 4240 4570 4320 4570 {lab=D[6]}
N 4200 4480 4200 4600 {lab=G[9]}
N 3740 4480 4200 4480 {lab=G[9]}
N 4240 4630 4240 4750 {lab=S[9]}
N 3780 4750 4240 4750 {lab=S[9]}
N 4700 4600 4760 4600 {lab=B}
N 4700 4570 4780 4570 {lab=D[7]}
N 4660 4480 4660 4600 {lab=G[9]}
N 4200 4480 4660 4480 {lab=G[9]}
N 4700 4630 4700 4750 {lab=S[9]}
N 4240 4750 4700 4750 {lab=S[9]}
N 5160 4600 5220 4600 {lab=B}
N 5160 4570 5240 4570 {lab=D[8]}
N 5120 4480 5120 4600 {lab=G[9]}
N 4660 4480 5120 4480 {lab=G[9]}
N 5160 4630 5160 4750 {lab=S[9]}
N 4700 4750 5160 4750 {lab=S[9]}
N 5620 4600 5680 4600 {lab=B}
N 5620 4570 5700 4570 {lab=D[9]}
N 5580 4480 5580 4600 {lab=G[9]}
N 5120 4480 5580 4480 {lab=G[9]}
N 5620 4630 5620 4750 {lab=S[9]}
N 5160 4750 5620 4750 {lab=S[9]}
N 6080 4600 6140 4600 {lab=B}
N 6080 4570 6160 4570 {lab=D[10]}
N 6040 4480 6040 4600 {lab=G[9]}
N 5580 4480 6040 4480 {lab=G[9]}
N 6080 4630 6080 4750 {lab=S[9]}
N 5620 4750 6080 4750 {lab=S[9]}
N 6540 4600 6600 4600 {lab=B}
N 6540 4570 6620 4570 {lab=D[11]}
N 6500 4480 6500 4600 {lab=G[9]}
N 6040 4480 6500 4480 {lab=G[9]}
N 6540 4630 6540 4750 {lab=S[9]}
N 6080 4750 6540 4750 {lab=S[9]}
N 7000 4600 7060 4600 {lab=B}
N 7000 4570 7080 4570 {lab=D[12]}
N 6960 4480 6960 4600 {lab=G[9]}
N 6500 4480 6960 4480 {lab=G[9]}
N 7000 4630 7000 4750 {lab=S[9]}
N 6540 4750 7000 4750 {lab=S[9]}
N 7460 4600 7520 4600 {lab=B}
N 7460 4570 7540 4570 {lab=D[13]}
N 7420 4480 7420 4600 {lab=G[9]}
N 6960 4480 7420 4480 {lab=G[9]}
N 7460 4630 7460 4750 {lab=S[9]}
N 7000 4750 7460 4750 {lab=S[9]}
N 7920 4600 7980 4600 {lab=B}
N 7920 4570 8000 4570 {lab=D[14]}
N 7880 4480 7880 4600 {lab=G[9]}
N 7420 4480 7880 4480 {lab=G[9]}
N 7920 4630 7920 4750 {lab=S[9]}
N 7460 4750 7920 4750 {lab=S[9]}
N 8380 4600 8440 4600 {lab=B}
N 8380 4570 8460 4570 {lab=D[15]}
N 8340 4480 8340 4600 {lab=G[9]}
N 7880 4480 8340 4480 {lab=G[9]}
N 8380 4630 8380 4750 {lab=S[9]}
N 7920 4750 8380 4750 {lab=S[9]}
N 8840 4600 8900 4600 {lab=B}
N 1020 4960 1080 4960 {lab=B}
N 1480 4960 1540 4960 {lab=B}
N 1480 4930 1560 4930 {lab=D[0]}
N 1440 4840 1440 4960 {lab=G[10]}
N 80 4840 1440 4840 {lab=G[10]}
N 1480 4990 1480 5110 {lab=S[10]}
N 80 5110 1480 5110 {lab=S[10]}
N 1940 4960 2000 4960 {lab=B}
N 1940 4930 2020 4930 {lab=D[1]}
N 1900 4840 1900 4960 {lab=G[10]}
N 1440 4840 1900 4840 {lab=G[10]}
N 1940 4990 1940 5110 {lab=S[10]}
N 1480 5110 1940 5110 {lab=S[10]}
N 2400 4960 2460 4960 {lab=B}
N 2400 4930 2480 4930 {lab=D[2]}
N 2360 4840 2360 4960 {lab=G[10]}
N 1900 4840 2360 4840 {lab=G[10]}
N 2400 4990 2400 5110 {lab=S[10]}
N 1940 5110 2400 5110 {lab=S[10]}
N 2860 4960 2920 4960 {lab=B}
N 2860 4930 2940 4930 {lab=D[3]}
N 2820 4840 2820 4960 {lab=G[10]}
N 2360 4840 2820 4840 {lab=G[10]}
N 2860 4990 2860 5110 {lab=S[10]}
N 2400 5110 2860 5110 {lab=S[10]}
N 3320 4960 3380 4960 {lab=B}
N 3320 4930 3400 4930 {lab=D[4]}
N 3280 4840 3280 4960 {lab=G[10]}
N 2820 4840 3280 4840 {lab=G[10]}
N 3320 4990 3320 5110 {lab=S[10]}
N 2860 5110 3320 5110 {lab=S[10]}
N 3780 4960 3840 4960 {lab=B}
N 3780 4930 3860 4930 {lab=D[5]}
N 3740 4840 3740 4960 {lab=G[10]}
N 3280 4840 3740 4840 {lab=G[10]}
N 3780 4990 3780 5110 {lab=S[10]}
N 3320 5110 3780 5110 {lab=S[10]}
N 4240 4960 4300 4960 {lab=B}
N 4240 4930 4320 4930 {lab=D[6]}
N 4200 4840 4200 4960 {lab=G[10]}
N 3740 4840 4200 4840 {lab=G[10]}
N 4240 4990 4240 5110 {lab=S[10]}
N 3780 5110 4240 5110 {lab=S[10]}
N 4700 4960 4760 4960 {lab=B}
N 4700 4930 4780 4930 {lab=D[7]}
N 4660 4840 4660 4960 {lab=G[10]}
N 4200 4840 4660 4840 {lab=G[10]}
N 4700 4990 4700 5110 {lab=S[10]}
N 4240 5110 4700 5110 {lab=S[10]}
N 5160 4960 5220 4960 {lab=B}
N 5160 4930 5240 4930 {lab=D[8]}
N 5120 4840 5120 4960 {lab=G[10]}
N 4660 4840 5120 4840 {lab=G[10]}
N 5160 4990 5160 5110 {lab=S[10]}
N 4700 5110 5160 5110 {lab=S[10]}
N 5620 4960 5680 4960 {lab=B}
N 5620 4930 5700 4930 {lab=D[9]}
N 5580 4840 5580 4960 {lab=G[10]}
N 5120 4840 5580 4840 {lab=G[10]}
N 5620 4990 5620 5110 {lab=S[10]}
N 5160 5110 5620 5110 {lab=S[10]}
N 6080 4960 6140 4960 {lab=B}
N 6080 4930 6160 4930 {lab=D[10]}
N 6040 4840 6040 4960 {lab=G[10]}
N 5580 4840 6040 4840 {lab=G[10]}
N 6080 4990 6080 5110 {lab=S[10]}
N 5620 5110 6080 5110 {lab=S[10]}
N 6540 4960 6600 4960 {lab=B}
N 6540 4930 6620 4930 {lab=D[11]}
N 6500 4840 6500 4960 {lab=G[10]}
N 6040 4840 6500 4840 {lab=G[10]}
N 6540 4990 6540 5110 {lab=S[10]}
N 6080 5110 6540 5110 {lab=S[10]}
N 7000 4960 7060 4960 {lab=B}
N 7000 4930 7080 4930 {lab=D[12]}
N 6960 4840 6960 4960 {lab=G[10]}
N 6500 4840 6960 4840 {lab=G[10]}
N 7000 4990 7000 5110 {lab=S[10]}
N 6540 5110 7000 5110 {lab=S[10]}
N 7460 4960 7520 4960 {lab=B}
N 7460 4930 7540 4930 {lab=D[13]}
N 7420 4840 7420 4960 {lab=G[10]}
N 6960 4840 7420 4840 {lab=G[10]}
N 7460 4990 7460 5110 {lab=S[10]}
N 7000 5110 7460 5110 {lab=S[10]}
N 7920 4960 7980 4960 {lab=B}
N 7920 4930 8000 4930 {lab=D[14]}
N 7880 4840 7880 4960 {lab=G[10]}
N 7420 4840 7880 4840 {lab=G[10]}
N 7920 4990 7920 5110 {lab=S[10]}
N 7460 5110 7920 5110 {lab=S[10]}
N 8380 4960 8440 4960 {lab=B}
N 8380 4930 8460 4930 {lab=D[15]}
N 8340 4840 8340 4960 {lab=G[10]}
N 7880 4840 8340 4840 {lab=G[10]}
N 8380 4990 8380 5110 {lab=S[10]}
N 7920 5110 8380 5110 {lab=S[10]}
N 8840 4960 8900 4960 {lab=B}
N 1020 5320 1080 5320 {lab=B}
N 1480 5320 1540 5320 {lab=B}
N 1480 5290 1560 5290 {lab=D[0]}
N 1440 5200 1440 5320 {lab=G[11]}
N 80 5200 1440 5200 {lab=G[11]}
N 1480 5350 1480 5470 {lab=S[11]}
N 80 5470 1480 5470 {lab=S[11]}
N 1940 5320 2000 5320 {lab=B}
N 1940 5290 2020 5290 {lab=D[1]}
N 1900 5200 1900 5320 {lab=G[11]}
N 1440 5200 1900 5200 {lab=G[11]}
N 1940 5350 1940 5470 {lab=S[11]}
N 1480 5470 1940 5470 {lab=S[11]}
N 2400 5320 2460 5320 {lab=B}
N 2400 5290 2480 5290 {lab=D[2]}
N 2360 5200 2360 5320 {lab=G[11]}
N 1900 5200 2360 5200 {lab=G[11]}
N 2400 5350 2400 5470 {lab=S[11]}
N 1940 5470 2400 5470 {lab=S[11]}
N 2860 5320 2920 5320 {lab=B}
N 2860 5290 2940 5290 {lab=D[3]}
N 2820 5200 2820 5320 {lab=G[11]}
N 2360 5200 2820 5200 {lab=G[11]}
N 2860 5350 2860 5470 {lab=S[11]}
N 2400 5470 2860 5470 {lab=S[11]}
N 3320 5320 3380 5320 {lab=B}
N 3320 5290 3400 5290 {lab=D[4]}
N 3280 5200 3280 5320 {lab=G[11]}
N 2820 5200 3280 5200 {lab=G[11]}
N 3320 5350 3320 5470 {lab=S[11]}
N 2860 5470 3320 5470 {lab=S[11]}
N 3780 5320 3840 5320 {lab=B}
N 3780 5290 3860 5290 {lab=D[5]}
N 3740 5200 3740 5320 {lab=G[11]}
N 3280 5200 3740 5200 {lab=G[11]}
N 3780 5350 3780 5470 {lab=S[11]}
N 3320 5470 3780 5470 {lab=S[11]}
N 4240 5320 4300 5320 {lab=B}
N 4240 5290 4320 5290 {lab=D[6]}
N 4200 5200 4200 5320 {lab=G[11]}
N 3740 5200 4200 5200 {lab=G[11]}
N 4240 5350 4240 5470 {lab=S[11]}
N 3780 5470 4240 5470 {lab=S[11]}
N 4700 5320 4760 5320 {lab=B}
N 4700 5290 4780 5290 {lab=D[7]}
N 4660 5200 4660 5320 {lab=G[11]}
N 4200 5200 4660 5200 {lab=G[11]}
N 4700 5350 4700 5470 {lab=S[11]}
N 4240 5470 4700 5470 {lab=S[11]}
N 5160 5320 5220 5320 {lab=B}
N 5160 5290 5240 5290 {lab=D[8]}
N 5120 5200 5120 5320 {lab=G[11]}
N 4660 5200 5120 5200 {lab=G[11]}
N 5160 5350 5160 5470 {lab=S[11]}
N 4700 5470 5160 5470 {lab=S[11]}
N 5620 5320 5680 5320 {lab=B}
N 5620 5290 5700 5290 {lab=D[9]}
N 5580 5200 5580 5320 {lab=G[11]}
N 5120 5200 5580 5200 {lab=G[11]}
N 5620 5350 5620 5470 {lab=S[11]}
N 5160 5470 5620 5470 {lab=S[11]}
N 6080 5320 6140 5320 {lab=B}
N 6080 5290 6160 5290 {lab=D[10]}
N 6040 5200 6040 5320 {lab=G[11]}
N 5580 5200 6040 5200 {lab=G[11]}
N 6080 5350 6080 5470 {lab=S[11]}
N 5620 5470 6080 5470 {lab=S[11]}
N 6540 5320 6600 5320 {lab=B}
N 6540 5290 6620 5290 {lab=D[11]}
N 6500 5200 6500 5320 {lab=G[11]}
N 6040 5200 6500 5200 {lab=G[11]}
N 6540 5350 6540 5470 {lab=S[11]}
N 6080 5470 6540 5470 {lab=S[11]}
N 7000 5320 7060 5320 {lab=B}
N 7000 5290 7080 5290 {lab=D[12]}
N 6960 5200 6960 5320 {lab=G[11]}
N 6500 5200 6960 5200 {lab=G[11]}
N 7000 5350 7000 5470 {lab=S[11]}
N 6540 5470 7000 5470 {lab=S[11]}
N 7460 5320 7520 5320 {lab=B}
N 7460 5290 7540 5290 {lab=D[13]}
N 7420 5200 7420 5320 {lab=G[11]}
N 6960 5200 7420 5200 {lab=G[11]}
N 7460 5350 7460 5470 {lab=S[11]}
N 7000 5470 7460 5470 {lab=S[11]}
N 7920 5320 7980 5320 {lab=B}
N 7920 5290 8000 5290 {lab=D[14]}
N 7880 5200 7880 5320 {lab=G[11]}
N 7420 5200 7880 5200 {lab=G[11]}
N 7920 5350 7920 5470 {lab=S[11]}
N 7460 5470 7920 5470 {lab=S[11]}
N 8380 5320 8440 5320 {lab=B}
N 8380 5290 8460 5290 {lab=D[15]}
N 8340 5200 8340 5320 {lab=G[11]}
N 7880 5200 8340 5200 {lab=G[11]}
N 8380 5350 8380 5470 {lab=S[11]}
N 7920 5470 8380 5470 {lab=S[11]}
N 8840 5320 8900 5320 {lab=B}
N 1020 5680 1080 5680 {lab=B}
N 1480 5680 1540 5680 {lab=B}
N 1480 5650 1560 5650 {lab=D[0]}
N 1440 5560 1440 5680 {lab=G[12]}
N 80 5560 1440 5560 {lab=G[12]}
N 1480 5710 1480 5830 {lab=S[12]}
N 80 5830 1480 5830 {lab=S[12]}
N 1940 5680 2000 5680 {lab=B}
N 1940 5650 2020 5650 {lab=D[1]}
N 1900 5560 1900 5680 {lab=G[12]}
N 1440 5560 1900 5560 {lab=G[12]}
N 1940 5710 1940 5830 {lab=S[12]}
N 1480 5830 1940 5830 {lab=S[12]}
N 2400 5680 2460 5680 {lab=B}
N 2400 5650 2480 5650 {lab=D[2]}
N 2360 5560 2360 5680 {lab=G[12]}
N 1900 5560 2360 5560 {lab=G[12]}
N 2400 5710 2400 5830 {lab=S[12]}
N 1940 5830 2400 5830 {lab=S[12]}
N 2860 5680 2920 5680 {lab=B}
N 2860 5650 2940 5650 {lab=D[3]}
N 2820 5560 2820 5680 {lab=G[12]}
N 2360 5560 2820 5560 {lab=G[12]}
N 2860 5710 2860 5830 {lab=S[12]}
N 2400 5830 2860 5830 {lab=S[12]}
N 3320 5680 3380 5680 {lab=B}
N 3320 5650 3400 5650 {lab=D[4]}
N 3280 5560 3280 5680 {lab=G[12]}
N 2820 5560 3280 5560 {lab=G[12]}
N 3320 5710 3320 5830 {lab=S[12]}
N 2860 5830 3320 5830 {lab=S[12]}
N 3780 5680 3840 5680 {lab=B}
N 3780 5650 3860 5650 {lab=D[5]}
N 3740 5560 3740 5680 {lab=G[12]}
N 3280 5560 3740 5560 {lab=G[12]}
N 3780 5710 3780 5830 {lab=S[12]}
N 3320 5830 3780 5830 {lab=S[12]}
N 4240 5680 4300 5680 {lab=B}
N 4240 5650 4320 5650 {lab=D[6]}
N 4200 5560 4200 5680 {lab=G[12]}
N 3740 5560 4200 5560 {lab=G[12]}
N 4240 5710 4240 5830 {lab=S[12]}
N 3780 5830 4240 5830 {lab=S[12]}
N 4700 5680 4760 5680 {lab=B}
N 4700 5650 4780 5650 {lab=D[7]}
N 4660 5560 4660 5680 {lab=G[12]}
N 4200 5560 4660 5560 {lab=G[12]}
N 4700 5710 4700 5830 {lab=S[12]}
N 4240 5830 4700 5830 {lab=S[12]}
N 5160 5680 5220 5680 {lab=B}
N 5160 5650 5240 5650 {lab=D[8]}
N 5120 5560 5120 5680 {lab=G[12]}
N 4660 5560 5120 5560 {lab=G[12]}
N 5160 5710 5160 5830 {lab=S[12]}
N 4700 5830 5160 5830 {lab=S[12]}
N 5620 5680 5680 5680 {lab=B}
N 5620 5650 5700 5650 {lab=D[9]}
N 5580 5560 5580 5680 {lab=G[12]}
N 5120 5560 5580 5560 {lab=G[12]}
N 5620 5710 5620 5830 {lab=S[12]}
N 5160 5830 5620 5830 {lab=S[12]}
N 6080 5680 6140 5680 {lab=B}
N 6080 5650 6160 5650 {lab=D[10]}
N 6040 5560 6040 5680 {lab=G[12]}
N 5580 5560 6040 5560 {lab=G[12]}
N 6080 5710 6080 5830 {lab=S[12]}
N 5620 5830 6080 5830 {lab=S[12]}
N 6540 5680 6600 5680 {lab=B}
N 6540 5650 6620 5650 {lab=D[11]}
N 6500 5560 6500 5680 {lab=G[12]}
N 6040 5560 6500 5560 {lab=G[12]}
N 6540 5710 6540 5830 {lab=S[12]}
N 6080 5830 6540 5830 {lab=S[12]}
N 7000 5680 7060 5680 {lab=B}
N 7000 5650 7080 5650 {lab=D[12]}
N 6960 5560 6960 5680 {lab=G[12]}
N 6500 5560 6960 5560 {lab=G[12]}
N 7000 5710 7000 5830 {lab=S[12]}
N 6540 5830 7000 5830 {lab=S[12]}
N 7460 5680 7520 5680 {lab=B}
N 7460 5650 7540 5650 {lab=D[13]}
N 7420 5560 7420 5680 {lab=G[12]}
N 6960 5560 7420 5560 {lab=G[12]}
N 7460 5710 7460 5830 {lab=S[12]}
N 7000 5830 7460 5830 {lab=S[12]}
N 7920 5680 7980 5680 {lab=B}
N 7920 5650 8000 5650 {lab=D[14]}
N 7880 5560 7880 5680 {lab=G[12]}
N 7420 5560 7880 5560 {lab=G[12]}
N 7920 5710 7920 5830 {lab=S[12]}
N 7460 5830 7920 5830 {lab=S[12]}
N 8380 5680 8440 5680 {lab=B}
N 8380 5650 8460 5650 {lab=D[15]}
N 8340 5560 8340 5680 {lab=G[12]}
N 7880 5560 8340 5560 {lab=G[12]}
N 8380 5710 8380 5830 {lab=S[12]}
N 7920 5830 8380 5830 {lab=S[12]}
N 8840 5680 8900 5680 {lab=B}
N 1020 6040 1080 6040 {lab=B}
N 1480 6040 1540 6040 {lab=B}
N 1480 6010 1560 6010 {lab=D[0]}
N 1440 5920 1440 6040 {lab=G[13]}
N 80 5920 1440 5920 {lab=G[13]}
N 1480 6070 1480 6190 {lab=S[13]}
N 80 6190 1480 6190 {lab=S[13]}
N 1940 6040 2000 6040 {lab=B}
N 1940 6010 2020 6010 {lab=D[1]}
N 1900 5920 1900 6040 {lab=G[13]}
N 1440 5920 1900 5920 {lab=G[13]}
N 1940 6070 1940 6190 {lab=S[13]}
N 1480 6190 1940 6190 {lab=S[13]}
N 2400 6040 2460 6040 {lab=B}
N 2400 6010 2480 6010 {lab=D[2]}
N 2360 5920 2360 6040 {lab=G[13]}
N 1900 5920 2360 5920 {lab=G[13]}
N 2400 6070 2400 6190 {lab=S[13]}
N 1940 6190 2400 6190 {lab=S[13]}
N 2860 6040 2920 6040 {lab=B}
N 2860 6010 2940 6010 {lab=D[3]}
N 2820 5920 2820 6040 {lab=G[13]}
N 2360 5920 2820 5920 {lab=G[13]}
N 2860 6070 2860 6190 {lab=S[13]}
N 2400 6190 2860 6190 {lab=S[13]}
N 3320 6040 3380 6040 {lab=B}
N 3320 6010 3400 6010 {lab=D[4]}
N 3280 5920 3280 6040 {lab=G[13]}
N 2820 5920 3280 5920 {lab=G[13]}
N 3320 6070 3320 6190 {lab=S[13]}
N 2860 6190 3320 6190 {lab=S[13]}
N 3780 6040 3840 6040 {lab=B}
N 3780 6010 3860 6010 {lab=D[5]}
N 3740 5920 3740 6040 {lab=G[13]}
N 3280 5920 3740 5920 {lab=G[13]}
N 3780 6070 3780 6190 {lab=S[13]}
N 3320 6190 3780 6190 {lab=S[13]}
N 4240 6040 4300 6040 {lab=B}
N 4240 6010 4320 6010 {lab=D[6]}
N 4200 5920 4200 6040 {lab=G[13]}
N 3740 5920 4200 5920 {lab=G[13]}
N 4240 6070 4240 6190 {lab=S[13]}
N 3780 6190 4240 6190 {lab=S[13]}
N 4700 6040 4760 6040 {lab=B}
N 4700 6010 4780 6010 {lab=D[7]}
N 4660 5920 4660 6040 {lab=G[13]}
N 4200 5920 4660 5920 {lab=G[13]}
N 4700 6070 4700 6190 {lab=S[13]}
N 4240 6190 4700 6190 {lab=S[13]}
N 5160 6040 5220 6040 {lab=B}
N 5160 6010 5240 6010 {lab=D[8]}
N 5120 5920 5120 6040 {lab=G[13]}
N 4660 5920 5120 5920 {lab=G[13]}
N 5160 6070 5160 6190 {lab=S[13]}
N 4700 6190 5160 6190 {lab=S[13]}
N 5620 6040 5680 6040 {lab=B}
N 5620 6010 5700 6010 {lab=D[9]}
N 5580 5920 5580 6040 {lab=G[13]}
N 5120 5920 5580 5920 {lab=G[13]}
N 5620 6070 5620 6190 {lab=S[13]}
N 5160 6190 5620 6190 {lab=S[13]}
N 6080 6040 6140 6040 {lab=B}
N 6080 6010 6160 6010 {lab=D[10]}
N 6040 5920 6040 6040 {lab=G[13]}
N 5580 5920 6040 5920 {lab=G[13]}
N 6080 6070 6080 6190 {lab=S[13]}
N 5620 6190 6080 6190 {lab=S[13]}
N 6540 6040 6600 6040 {lab=B}
N 6540 6010 6620 6010 {lab=D[11]}
N 6500 5920 6500 6040 {lab=G[13]}
N 6040 5920 6500 5920 {lab=G[13]}
N 6540 6070 6540 6190 {lab=S[13]}
N 6080 6190 6540 6190 {lab=S[13]}
N 7000 6040 7060 6040 {lab=B}
N 7000 6010 7080 6010 {lab=D[12]}
N 6960 5920 6960 6040 {lab=G[13]}
N 6500 5920 6960 5920 {lab=G[13]}
N 7000 6070 7000 6190 {lab=S[13]}
N 6540 6190 7000 6190 {lab=S[13]}
N 7460 6040 7520 6040 {lab=B}
N 7460 6010 7540 6010 {lab=D[13]}
N 7420 5920 7420 6040 {lab=G[13]}
N 6960 5920 7420 5920 {lab=G[13]}
N 7460 6070 7460 6190 {lab=S[13]}
N 7000 6190 7460 6190 {lab=S[13]}
N 7920 6040 7980 6040 {lab=B}
N 7920 6010 8000 6010 {lab=D[14]}
N 7880 5920 7880 6040 {lab=G[13]}
N 7420 5920 7880 5920 {lab=G[13]}
N 7920 6070 7920 6190 {lab=S[13]}
N 7460 6190 7920 6190 {lab=S[13]}
N 8380 6040 8440 6040 {lab=B}
N 8380 6010 8460 6010 {lab=D[15]}
N 8340 5920 8340 6040 {lab=G[13]}
N 7880 5920 8340 5920 {lab=G[13]}
N 8380 6070 8380 6190 {lab=S[13]}
N 7920 6190 8380 6190 {lab=S[13]}
N 8840 6040 8900 6040 {lab=B}
N 1020 6400 1080 6400 {lab=B}
N 1480 6400 1540 6400 {lab=B}
N 1480 6370 1560 6370 {lab=D[0]}
N 1440 6280 1440 6400 {lab=G[14]}
N 80 6280 1440 6280 {lab=G[14]}
N 1480 6430 1480 6550 {lab=S[14]}
N 80 6550 1480 6550 {lab=S[14]}
N 1940 6400 2000 6400 {lab=B}
N 1940 6370 2020 6370 {lab=D[1]}
N 1900 6280 1900 6400 {lab=G[14]}
N 1440 6280 1900 6280 {lab=G[14]}
N 1940 6430 1940 6550 {lab=S[14]}
N 1480 6550 1940 6550 {lab=S[14]}
N 2400 6400 2460 6400 {lab=B}
N 2400 6370 2480 6370 {lab=D[2]}
N 2360 6280 2360 6400 {lab=G[14]}
N 1900 6280 2360 6280 {lab=G[14]}
N 2400 6430 2400 6550 {lab=S[14]}
N 1940 6550 2400 6550 {lab=S[14]}
N 2860 6400 2920 6400 {lab=B}
N 2860 6370 2940 6370 {lab=D[3]}
N 2820 6280 2820 6400 {lab=G[14]}
N 2360 6280 2820 6280 {lab=G[14]}
N 2860 6430 2860 6550 {lab=S[14]}
N 2400 6550 2860 6550 {lab=S[14]}
N 3320 6400 3380 6400 {lab=B}
N 3320 6370 3400 6370 {lab=D[4]}
N 3280 6280 3280 6400 {lab=G[14]}
N 2820 6280 3280 6280 {lab=G[14]}
N 3320 6430 3320 6550 {lab=S[14]}
N 2860 6550 3320 6550 {lab=S[14]}
N 3780 6400 3840 6400 {lab=B}
N 3780 6370 3860 6370 {lab=D[5]}
N 3740 6280 3740 6400 {lab=G[14]}
N 3280 6280 3740 6280 {lab=G[14]}
N 3780 6430 3780 6550 {lab=S[14]}
N 3320 6550 3780 6550 {lab=S[14]}
N 4240 6400 4300 6400 {lab=B}
N 4240 6370 4320 6370 {lab=D[6]}
N 4200 6280 4200 6400 {lab=G[14]}
N 3740 6280 4200 6280 {lab=G[14]}
N 4240 6430 4240 6550 {lab=S[14]}
N 3780 6550 4240 6550 {lab=S[14]}
N 4700 6400 4760 6400 {lab=B}
N 4700 6370 4780 6370 {lab=D[7]}
N 4660 6280 4660 6400 {lab=G[14]}
N 4200 6280 4660 6280 {lab=G[14]}
N 4700 6430 4700 6550 {lab=S[14]}
N 4240 6550 4700 6550 {lab=S[14]}
N 5160 6400 5220 6400 {lab=B}
N 5160 6370 5240 6370 {lab=D[8]}
N 5120 6280 5120 6400 {lab=G[14]}
N 4660 6280 5120 6280 {lab=G[14]}
N 5160 6430 5160 6550 {lab=S[14]}
N 4700 6550 5160 6550 {lab=S[14]}
N 5620 6400 5680 6400 {lab=B}
N 5620 6370 5700 6370 {lab=D[9]}
N 5580 6280 5580 6400 {lab=G[14]}
N 5120 6280 5580 6280 {lab=G[14]}
N 5620 6430 5620 6550 {lab=S[14]}
N 5160 6550 5620 6550 {lab=S[14]}
N 6080 6400 6140 6400 {lab=B}
N 6080 6370 6160 6370 {lab=D[10]}
N 6040 6280 6040 6400 {lab=G[14]}
N 5580 6280 6040 6280 {lab=G[14]}
N 6080 6430 6080 6550 {lab=S[14]}
N 5620 6550 6080 6550 {lab=S[14]}
N 6540 6400 6600 6400 {lab=B}
N 6540 6370 6620 6370 {lab=D[11]}
N 6500 6280 6500 6400 {lab=G[14]}
N 6040 6280 6500 6280 {lab=G[14]}
N 6540 6430 6540 6550 {lab=S[14]}
N 6080 6550 6540 6550 {lab=S[14]}
N 7000 6400 7060 6400 {lab=B}
N 7000 6370 7080 6370 {lab=D[12]}
N 6960 6280 6960 6400 {lab=G[14]}
N 6500 6280 6960 6280 {lab=G[14]}
N 7000 6430 7000 6550 {lab=S[14]}
N 6540 6550 7000 6550 {lab=S[14]}
N 7460 6400 7520 6400 {lab=B}
N 7460 6370 7540 6370 {lab=D[13]}
N 7420 6280 7420 6400 {lab=G[14]}
N 6960 6280 7420 6280 {lab=G[14]}
N 7460 6430 7460 6550 {lab=S[14]}
N 7000 6550 7460 6550 {lab=S[14]}
N 7920 6400 7980 6400 {lab=B}
N 7920 6370 8000 6370 {lab=D[14]}
N 7880 6280 7880 6400 {lab=G[14]}
N 7420 6280 7880 6280 {lab=G[14]}
N 7920 6430 7920 6550 {lab=S[14]}
N 7460 6550 7920 6550 {lab=S[14]}
N 8380 6400 8440 6400 {lab=B}
N 8380 6370 8460 6370 {lab=D[15]}
N 8340 6280 8340 6400 {lab=G[14]}
N 7880 6280 8340 6280 {lab=G[14]}
N 8380 6430 8380 6550 {lab=S[14]}
N 7920 6550 8380 6550 {lab=S[14]}
N 8840 6400 8900 6400 {lab=B}
N 1020 6760 1080 6760 {lab=B}
N 1480 6760 1540 6760 {lab=B}
N 1480 6730 1560 6730 {lab=D[0]}
N 1440 6640 1440 6760 {lab=G[15]}
N 80 6640 1440 6640 {lab=G[15]}
N 1480 6790 1480 6910 {lab=S[15]}
N 80 6910 1480 6910 {lab=S[15]}
N 1940 6760 2000 6760 {lab=B}
N 1940 6730 2020 6730 {lab=D[1]}
N 1900 6640 1900 6760 {lab=G[15]}
N 1440 6640 1900 6640 {lab=G[15]}
N 1940 6790 1940 6910 {lab=S[15]}
N 1480 6910 1940 6910 {lab=S[15]}
N 2400 6760 2460 6760 {lab=B}
N 2400 6730 2480 6730 {lab=D[2]}
N 2360 6640 2360 6760 {lab=G[15]}
N 1900 6640 2360 6640 {lab=G[15]}
N 2400 6790 2400 6910 {lab=S[15]}
N 1940 6910 2400 6910 {lab=S[15]}
N 2860 6760 2920 6760 {lab=B}
N 2860 6730 2940 6730 {lab=D[3]}
N 2820 6640 2820 6760 {lab=G[15]}
N 2360 6640 2820 6640 {lab=G[15]}
N 2860 6790 2860 6910 {lab=S[15]}
N 2400 6910 2860 6910 {lab=S[15]}
N 3320 6760 3380 6760 {lab=B}
N 3320 6730 3400 6730 {lab=D[4]}
N 3280 6640 3280 6760 {lab=G[15]}
N 2820 6640 3280 6640 {lab=G[15]}
N 3320 6790 3320 6910 {lab=S[15]}
N 2860 6910 3320 6910 {lab=S[15]}
N 3780 6760 3840 6760 {lab=B}
N 3780 6730 3860 6730 {lab=D[5]}
N 3740 6640 3740 6760 {lab=G[15]}
N 3280 6640 3740 6640 {lab=G[15]}
N 3780 6790 3780 6910 {lab=S[15]}
N 3320 6910 3780 6910 {lab=S[15]}
N 4240 6760 4300 6760 {lab=B}
N 4240 6730 4320 6730 {lab=D[6]}
N 4200 6640 4200 6760 {lab=G[15]}
N 3740 6640 4200 6640 {lab=G[15]}
N 4240 6790 4240 6910 {lab=S[15]}
N 3780 6910 4240 6910 {lab=S[15]}
N 4700 6760 4760 6760 {lab=B}
N 4700 6730 4780 6730 {lab=D[7]}
N 4660 6640 4660 6760 {lab=G[15]}
N 4200 6640 4660 6640 {lab=G[15]}
N 4700 6790 4700 6910 {lab=S[15]}
N 4240 6910 4700 6910 {lab=S[15]}
N 5160 6760 5220 6760 {lab=B}
N 5160 6730 5240 6730 {lab=D[8]}
N 5120 6640 5120 6760 {lab=G[15]}
N 4660 6640 5120 6640 {lab=G[15]}
N 5160 6790 5160 6910 {lab=S[15]}
N 4700 6910 5160 6910 {lab=S[15]}
N 5620 6760 5680 6760 {lab=B}
N 5620 6730 5700 6730 {lab=D[9]}
N 5580 6640 5580 6760 {lab=G[15]}
N 5120 6640 5580 6640 {lab=G[15]}
N 5620 6790 5620 6910 {lab=S[15]}
N 5160 6910 5620 6910 {lab=S[15]}
N 6080 6760 6140 6760 {lab=B}
N 6080 6730 6160 6730 {lab=D[10]}
N 6040 6640 6040 6760 {lab=G[15]}
N 5580 6640 6040 6640 {lab=G[15]}
N 6080 6790 6080 6910 {lab=S[15]}
N 5620 6910 6080 6910 {lab=S[15]}
N 6540 6760 6600 6760 {lab=B}
N 6540 6730 6620 6730 {lab=D[11]}
N 6500 6640 6500 6760 {lab=G[15]}
N 6040 6640 6500 6640 {lab=G[15]}
N 6540 6790 6540 6910 {lab=S[15]}
N 6080 6910 6540 6910 {lab=S[15]}
N 7000 6760 7060 6760 {lab=B}
N 7000 6730 7080 6730 {lab=D[12]}
N 6960 6640 6960 6760 {lab=G[15]}
N 6500 6640 6960 6640 {lab=G[15]}
N 7000 6790 7000 6910 {lab=S[15]}
N 6540 6910 7000 6910 {lab=S[15]}
N 7460 6760 7520 6760 {lab=B}
N 7460 6730 7540 6730 {lab=D[13]}
N 7420 6640 7420 6760 {lab=G[15]}
N 6960 6640 7420 6640 {lab=G[15]}
N 7460 6790 7460 6910 {lab=S[15]}
N 7000 6910 7460 6910 {lab=S[15]}
N 7920 6760 7980 6760 {lab=B}
N 7920 6730 8000 6730 {lab=D[14]}
N 7880 6640 7880 6760 {lab=G[15]}
N 7420 6640 7880 6640 {lab=G[15]}
N 7920 6790 7920 6910 {lab=S[15]}
N 7460 6910 7920 6910 {lab=S[15]}
N 8380 6760 8440 6760 {lab=B}
N 8380 6730 8460 6730 {lab=D[15]}
N 8340 6640 8340 6760 {lab=G[15]}
N 7880 6640 8340 6640 {lab=G[15]}
N 8380 6790 8380 6910 {lab=S[15]}
N 7920 6910 8380 6910 {lab=S[15]}
N 8840 6760 8900 6760 {lab=B}
N 1020 7120 1080 7120 {lab=B}
N 1480 7120 1540 7120 {lab=B}
N 1940 7120 2000 7120 {lab=B}
N 2400 7120 2460 7120 {lab=B}
N 2860 7120 2920 7120 {lab=B}
N 3320 7120 3380 7120 {lab=B}
N 3780 7120 3840 7120 {lab=B}
N 4240 7120 4300 7120 {lab=B}
N 4700 7120 4760 7120 {lab=B}
N 5160 7120 5220 7120 {lab=B}
N 5620 7120 5680 7120 {lab=B}
N 6080 7120 6140 7120 {lab=B}
N 6540 7120 6600 7120 {lab=B}
N 7000 7120 7060 7120 {lab=B}
N 7460 7120 7520 7120 {lab=B}
N 7920 7120 7980 7120 {lab=B}
N 8380 7120 8440 7120 {lab=B}
N 8840 7120 8900 7120 {lab=B}
N 1560 970 1560 1330 {lab=D[0]}
N 2020 970 2020 1330 {lab=D[1]}
N 2480 970 2480 1330 {lab=D[2]}
N 2940 970 2940 1330 {lab=D[3]}
N 3400 970 3400 1330 {lab=D[4]}
N 3860 970 3860 1330 {lab=D[5]}
N 4320 970 4320 1330 {lab=D[6]}
N 4780 970 4780 1330 {lab=D[7]}
N 5240 970 5240 1330 {lab=D[8]}
N 5700 970 5700 1330 {lab=D[9]}
N 6160 970 6160 1330 {lab=D[10]}
N 6620 970 6620 1330 {lab=D[11]}
N 7080 970 7080 1330 {lab=D[12]}
N 7540 970 7540 1330 {lab=D[13]}
N 8000 970 8000 1330 {lab=D[14]}
N 8460 970 8460 1330 {lab=D[15]}
N 1560 1330 1560 1690 {lab=D[0]}
N 2020 1330 2020 1690 {lab=D[1]}
N 2480 1330 2480 1690 {lab=D[2]}
N 2940 1330 2940 1690 {lab=D[3]}
N 3400 1330 3400 1690 {lab=D[4]}
N 3860 1330 3860 1690 {lab=D[5]}
N 4320 1330 4320 1690 {lab=D[6]}
N 4780 1330 4780 1690 {lab=D[7]}
N 5240 1330 5240 1690 {lab=D[8]}
N 5700 1330 5700 1690 {lab=D[9]}
N 6160 1330 6160 1690 {lab=D[10]}
N 6620 1330 6620 1690 {lab=D[11]}
N 7080 1330 7080 1690 {lab=D[12]}
N 7540 1330 7540 1690 {lab=D[13]}
N 8000 1330 8000 1690 {lab=D[14]}
N 8460 1330 8460 1690 {lab=D[15]}
N 1560 1690 1560 2050 {lab=D[0]}
N 2020 1690 2020 2050 {lab=D[1]}
N 2480 1690 2480 2050 {lab=D[2]}
N 2940 1690 2940 2050 {lab=D[3]}
N 3400 1690 3400 2050 {lab=D[4]}
N 3860 1690 3860 2050 {lab=D[5]}
N 4320 1690 4320 2050 {lab=D[6]}
N 4780 1690 4780 2050 {lab=D[7]}
N 5240 1690 5240 2050 {lab=D[8]}
N 5700 1690 5700 2050 {lab=D[9]}
N 6160 1690 6160 2050 {lab=D[10]}
N 6620 1690 6620 2050 {lab=D[11]}
N 7080 1690 7080 2050 {lab=D[12]}
N 7540 1690 7540 2050 {lab=D[13]}
N 8000 1690 8000 2050 {lab=D[14]}
N 8460 1690 8460 2050 {lab=D[15]}
N 1560 2050 1560 2410 {lab=D[0]}
N 2020 2050 2020 2410 {lab=D[1]}
N 2480 2050 2480 2410 {lab=D[2]}
N 2940 2050 2940 2410 {lab=D[3]}
N 3400 2050 3400 2410 {lab=D[4]}
N 3860 2050 3860 2410 {lab=D[5]}
N 4320 2050 4320 2410 {lab=D[6]}
N 4780 2050 4780 2410 {lab=D[7]}
N 5240 2050 5240 2410 {lab=D[8]}
N 5700 2050 5700 2410 {lab=D[9]}
N 6160 2050 6160 2410 {lab=D[10]}
N 6620 2050 6620 2410 {lab=D[11]}
N 7080 2050 7080 2410 {lab=D[12]}
N 7540 2050 7540 2410 {lab=D[13]}
N 8000 2050 8000 2410 {lab=D[14]}
N 8460 2050 8460 2410 {lab=D[15]}
N 1560 2410 1560 2770 {lab=D[0]}
N 2020 2410 2020 2770 {lab=D[1]}
N 2480 2410 2480 2770 {lab=D[2]}
N 2940 2410 2940 2770 {lab=D[3]}
N 3400 2410 3400 2770 {lab=D[4]}
N 3860 2410 3860 2770 {lab=D[5]}
N 4320 2410 4320 2770 {lab=D[6]}
N 4780 2410 4780 2770 {lab=D[7]}
N 5240 2410 5240 2770 {lab=D[8]}
N 5700 2410 5700 2770 {lab=D[9]}
N 6160 2410 6160 2770 {lab=D[10]}
N 6620 2410 6620 2770 {lab=D[11]}
N 7080 2410 7080 2770 {lab=D[12]}
N 7540 2410 7540 2770 {lab=D[13]}
N 8000 2410 8000 2770 {lab=D[14]}
N 8460 2410 8460 2770 {lab=D[15]}
N 1560 2770 1560 3130 {lab=D[0]}
N 2020 2770 2020 3130 {lab=D[1]}
N 2480 2770 2480 3130 {lab=D[2]}
N 2940 2770 2940 3130 {lab=D[3]}
N 3400 2770 3400 3130 {lab=D[4]}
N 3860 2770 3860 3130 {lab=D[5]}
N 4320 2770 4320 3130 {lab=D[6]}
N 4780 2770 4780 3130 {lab=D[7]}
N 5240 2770 5240 3130 {lab=D[8]}
N 5700 2770 5700 3130 {lab=D[9]}
N 6160 2770 6160 3130 {lab=D[10]}
N 6620 2770 6620 3130 {lab=D[11]}
N 7080 2770 7080 3130 {lab=D[12]}
N 7540 2770 7540 3130 {lab=D[13]}
N 8000 2770 8000 3130 {lab=D[14]}
N 8460 2770 8460 3130 {lab=D[15]}
N 1560 3130 1560 3490 {lab=D[0]}
N 2020 3130 2020 3490 {lab=D[1]}
N 2480 3130 2480 3490 {lab=D[2]}
N 2940 3130 2940 3490 {lab=D[3]}
N 3400 3130 3400 3490 {lab=D[4]}
N 3860 3130 3860 3490 {lab=D[5]}
N 4320 3130 4320 3490 {lab=D[6]}
N 4780 3130 4780 3490 {lab=D[7]}
N 5240 3130 5240 3490 {lab=D[8]}
N 5700 3130 5700 3490 {lab=D[9]}
N 6160 3130 6160 3490 {lab=D[10]}
N 6620 3130 6620 3490 {lab=D[11]}
N 7080 3130 7080 3490 {lab=D[12]}
N 7540 3130 7540 3490 {lab=D[13]}
N 8000 3130 8000 3490 {lab=D[14]}
N 8460 3130 8460 3490 {lab=D[15]}
N 1560 3490 1560 3850 {lab=D[0]}
N 2020 3490 2020 3850 {lab=D[1]}
N 2480 3490 2480 3850 {lab=D[2]}
N 2940 3490 2940 3850 {lab=D[3]}
N 3400 3490 3400 3850 {lab=D[4]}
N 3860 3490 3860 3850 {lab=D[5]}
N 4320 3490 4320 3850 {lab=D[6]}
N 4780 3490 4780 3850 {lab=D[7]}
N 5240 3490 5240 3850 {lab=D[8]}
N 5700 3490 5700 3850 {lab=D[9]}
N 6160 3490 6160 3850 {lab=D[10]}
N 6620 3490 6620 3850 {lab=D[11]}
N 7080 3490 7080 3850 {lab=D[12]}
N 7540 3490 7540 3850 {lab=D[13]}
N 8000 3490 8000 3850 {lab=D[14]}
N 8460 3490 8460 3850 {lab=D[15]}
N 1560 3850 1560 4210 {lab=D[0]}
N 2020 3850 2020 4210 {lab=D[1]}
N 2480 3850 2480 4210 {lab=D[2]}
N 2940 3850 2940 4210 {lab=D[3]}
N 3400 3850 3400 4210 {lab=D[4]}
N 3860 3850 3860 4210 {lab=D[5]}
N 4320 3850 4320 4210 {lab=D[6]}
N 4780 3850 4780 4210 {lab=D[7]}
N 5240 3850 5240 4210 {lab=D[8]}
N 5700 3850 5700 4210 {lab=D[9]}
N 6160 3850 6160 4210 {lab=D[10]}
N 6620 3850 6620 4210 {lab=D[11]}
N 7080 3850 7080 4210 {lab=D[12]}
N 7540 3850 7540 4210 {lab=D[13]}
N 8000 3850 8000 4210 {lab=D[14]}
N 8460 3850 8460 4210 {lab=D[15]}
N 1560 4210 1560 4570 {lab=D[0]}
N 2020 4210 2020 4570 {lab=D[1]}
N 2480 4210 2480 4570 {lab=D[2]}
N 2940 4210 2940 4570 {lab=D[3]}
N 3400 4210 3400 4570 {lab=D[4]}
N 3860 4210 3860 4570 {lab=D[5]}
N 4320 4210 4320 4570 {lab=D[6]}
N 4780 4210 4780 4570 {lab=D[7]}
N 5240 4210 5240 4570 {lab=D[8]}
N 5700 4210 5700 4570 {lab=D[9]}
N 6160 4210 6160 4570 {lab=D[10]}
N 6620 4210 6620 4570 {lab=D[11]}
N 7080 4210 7080 4570 {lab=D[12]}
N 7540 4210 7540 4570 {lab=D[13]}
N 8000 4210 8000 4570 {lab=D[14]}
N 8460 4210 8460 4570 {lab=D[15]}
N 1560 4570 1560 4930 {lab=D[0]}
N 2020 4570 2020 4930 {lab=D[1]}
N 2480 4570 2480 4930 {lab=D[2]}
N 2940 4570 2940 4930 {lab=D[3]}
N 3400 4570 3400 4930 {lab=D[4]}
N 3860 4570 3860 4930 {lab=D[5]}
N 4320 4570 4320 4930 {lab=D[6]}
N 4780 4570 4780 4930 {lab=D[7]}
N 5240 4570 5240 4930 {lab=D[8]}
N 5700 4570 5700 4930 {lab=D[9]}
N 6160 4570 6160 4930 {lab=D[10]}
N 6620 4570 6620 4930 {lab=D[11]}
N 7080 4570 7080 4930 {lab=D[12]}
N 7540 4570 7540 4930 {lab=D[13]}
N 8000 4570 8000 4930 {lab=D[14]}
N 8460 4570 8460 4930 {lab=D[15]}
N 1560 4930 1560 5290 {lab=D[0]}
N 2020 4930 2020 5290 {lab=D[1]}
N 2480 4930 2480 5290 {lab=D[2]}
N 2940 4930 2940 5290 {lab=D[3]}
N 3400 4930 3400 5290 {lab=D[4]}
N 3860 4930 3860 5290 {lab=D[5]}
N 4320 4930 4320 5290 {lab=D[6]}
N 4780 4930 4780 5290 {lab=D[7]}
N 5240 4930 5240 5290 {lab=D[8]}
N 5700 4930 5700 5290 {lab=D[9]}
N 6160 4930 6160 5290 {lab=D[10]}
N 6620 4930 6620 5290 {lab=D[11]}
N 7080 4930 7080 5290 {lab=D[12]}
N 7540 4930 7540 5290 {lab=D[13]}
N 8000 4930 8000 5290 {lab=D[14]}
N 8460 4930 8460 5290 {lab=D[15]}
N 1560 5290 1560 5650 {lab=D[0]}
N 2020 5290 2020 5650 {lab=D[1]}
N 2480 5290 2480 5650 {lab=D[2]}
N 2940 5290 2940 5650 {lab=D[3]}
N 3400 5290 3400 5650 {lab=D[4]}
N 3860 5290 3860 5650 {lab=D[5]}
N 4320 5290 4320 5650 {lab=D[6]}
N 4780 5290 4780 5650 {lab=D[7]}
N 5240 5290 5240 5650 {lab=D[8]}
N 5700 5290 5700 5650 {lab=D[9]}
N 6160 5290 6160 5650 {lab=D[10]}
N 6620 5290 6620 5650 {lab=D[11]}
N 7080 5290 7080 5650 {lab=D[12]}
N 7540 5290 7540 5650 {lab=D[13]}
N 8000 5290 8000 5650 {lab=D[14]}
N 8460 5290 8460 5650 {lab=D[15]}
N 1560 5650 1560 6010 {lab=D[0]}
N 2020 5650 2020 6010 {lab=D[1]}
N 2480 5650 2480 6010 {lab=D[2]}
N 2940 5650 2940 6010 {lab=D[3]}
N 3400 5650 3400 6010 {lab=D[4]}
N 3860 5650 3860 6010 {lab=D[5]}
N 4320 5650 4320 6010 {lab=D[6]}
N 4780 5650 4780 6010 {lab=D[7]}
N 5240 5650 5240 6010 {lab=D[8]}
N 5700 5650 5700 6010 {lab=D[9]}
N 6160 5650 6160 6010 {lab=D[10]}
N 6620 5650 6620 6010 {lab=D[11]}
N 7080 5650 7080 6010 {lab=D[12]}
N 7540 5650 7540 6010 {lab=D[13]}
N 8000 5650 8000 6010 {lab=D[14]}
N 8460 5650 8460 6010 {lab=D[15]}
N 1560 6010 1560 6370 {lab=D[0]}
N 2020 6010 2020 6370 {lab=D[1]}
N 2480 6010 2480 6370 {lab=D[2]}
N 2940 6010 2940 6370 {lab=D[3]}
N 3400 6010 3400 6370 {lab=D[4]}
N 3860 6010 3860 6370 {lab=D[5]}
N 4320 6010 4320 6370 {lab=D[6]}
N 4780 6010 4780 6370 {lab=D[7]}
N 5240 6010 5240 6370 {lab=D[8]}
N 5700 6010 5700 6370 {lab=D[9]}
N 6160 6010 6160 6370 {lab=D[10]}
N 6620 6010 6620 6370 {lab=D[11]}
N 7080 6010 7080 6370 {lab=D[12]}
N 7540 6010 7540 6370 {lab=D[13]}
N 8000 6010 8000 6370 {lab=D[14]}
N 8460 6010 8460 6370 {lab=D[15]}
C {devices/lab_pin.sym} 300 540 0 0 {name=lab_D_bus lab=D[0:15] dir=inout}
C {devices/iopin.sym} 480 540 0 0 {name=D_pin lab=D dir=inout}
C {devices/lab_pin.sym} 300 580 0 0 {name=lab_G_bus lab=G[0:15] dir=inout}
C {devices/iopin.sym} 480 580 0 0 {name=G_pin lab=G dir=inout}
C {devices/lab_pin.sym} 300 620 0 0 {name=lab_S_bus lab=S[0:15] dir=inout}
C {devices/iopin.sym} 480 620 0 0 {name=S_pin lab=S dir=inout}
C {devices/lab_pin.sym} 300 660 0 0 {name=lab_B_bus lab=B dir=inout}
C {devices/iopin.sym} 480 660 0 0 {name=B_pin lab=B dir=inout}
C {devices/lab_pin.sym} 100 1240 0 0 {name=lab_G[0]_100_1240 lab=G[0] dir=inout}
C {devices/lab_pin.sym} 100 1600 0 0 {name=lab_G[1]_100_1600 lab=G[1] dir=inout}
C {devices/lab_pin.sym} 100 1960 0 0 {name=lab_G[2]_100_1960 lab=G[2] dir=inout}
C {devices/lab_pin.sym} 100 2320 0 0 {name=lab_G[3]_100_2320 lab=G[3] dir=inout}
C {devices/lab_pin.sym} 100 2680 0 0 {name=lab_G[4]_100_2680 lab=G[4] dir=inout}
C {devices/lab_pin.sym} 100 3040 0 0 {name=lab_G[5]_100_3040 lab=G[5] dir=inout}
C {devices/lab_pin.sym} 100 3400 0 0 {name=lab_G[6]_100_3400 lab=G[6] dir=inout}
C {devices/lab_pin.sym} 100 3760 0 0 {name=lab_G[7]_100_3760 lab=G[7] dir=inout}
C {devices/lab_pin.sym} 100 4120 0 0 {name=lab_G[8]_100_4120 lab=G[8] dir=inout}
C {devices/lab_pin.sym} 100 4480 0 0 {name=lab_G[9]_100_4480 lab=G[9] dir=inout}
C {devices/lab_pin.sym} 100 4840 0 0 {name=lab_G[10]_100_4840 lab=G[10] dir=inout}
C {devices/lab_pin.sym} 100 5200 0 0 {name=lab_G[11]_100_5200 lab=G[11] dir=inout}
C {devices/lab_pin.sym} 100 5560 0 0 {name=lab_G[12]_100_5560 lab=G[12] dir=inout}
C {devices/lab_pin.sym} 100 5920 0 0 {name=lab_G[13]_100_5920 lab=G[13] dir=inout}
C {devices/lab_pin.sym} 100 6280 0 0 {name=lab_G[14]_100_6280 lab=G[14] dir=inout}
C {devices/lab_pin.sym} 100 6640 0 0 {name=lab_G[15]_100_6640 lab=G[15] dir=inout}
C {devices/lab_pin.sym} 100 1510 0 0 {name=lab_S[0]_100_1510 lab=S[0] dir=inout}
C {devices/lab_pin.sym} 100 1870 0 0 {name=lab_S[1]_100_1870 lab=S[1] dir=inout}
C {devices/lab_pin.sym} 100 2230 0 0 {name=lab_S[2]_100_2230 lab=S[2] dir=inout}
C {devices/lab_pin.sym} 100 2590 0 0 {name=lab_S[3]_100_2590 lab=S[3] dir=inout}
C {devices/lab_pin.sym} 100 2950 0 0 {name=lab_S[4]_100_2950 lab=S[4] dir=inout}
C {devices/lab_pin.sym} 100 3310 0 0 {name=lab_S[5]_100_3310 lab=S[5] dir=inout}
C {devices/lab_pin.sym} 100 3670 0 0 {name=lab_S[6]_100_3670 lab=S[6] dir=inout}
C {devices/lab_pin.sym} 100 4030 0 0 {name=lab_S[7]_100_4030 lab=S[7] dir=inout}
C {devices/lab_pin.sym} 100 4390 0 0 {name=lab_S[8]_100_4390 lab=S[8] dir=inout}
C {devices/lab_pin.sym} 100 4750 0 0 {name=lab_S[9]_100_4750 lab=S[9] dir=inout}
C {devices/lab_pin.sym} 100 5110 0 0 {name=lab_S[10]_100_5110 lab=S[10] dir=inout}
C {devices/lab_pin.sym} 100 5470 0 0 {name=lab_S[11]_100_5470 lab=S[11] dir=inout}
C {devices/lab_pin.sym} 100 5830 0 0 {name=lab_S[12]_100_5830 lab=S[12] dir=inout}
C {devices/lab_pin.sym} 100 6190 0 0 {name=lab_S[13]_100_6190 lab=S[13] dir=inout}
C {devices/lab_pin.sym} 100 6550 0 0 {name=lab_S[14]_100_6550 lab=S[14] dir=inout}
C {devices/lab_pin.sym} 100 6910 0 0 {name=lab_S[15]_100_6910 lab=S[15] dir=inout}
C {devices/lab_pin.sym} 1560 990 0 0 {name=lab_D[0]_1560_990 lab=D[0] dir=inout}
C {devices/lab_pin.sym} 2020 990 0 0 {name=lab_D[1]_2020_990 lab=D[1] dir=inout}
C {devices/lab_pin.sym} 2480 990 0 0 {name=lab_D[2]_2480_990 lab=D[2] dir=inout}
C {devices/lab_pin.sym} 2940 990 0 0 {name=lab_D[3]_2940_990 lab=D[3] dir=inout}
C {devices/lab_pin.sym} 3400 990 0 0 {name=lab_D[4]_3400_990 lab=D[4] dir=inout}
C {devices/lab_pin.sym} 3860 990 0 0 {name=lab_D[5]_3860_990 lab=D[5] dir=inout}
C {devices/lab_pin.sym} 4320 990 0 0 {name=lab_D[6]_4320_990 lab=D[6] dir=inout}
C {devices/lab_pin.sym} 4780 990 0 0 {name=lab_D[7]_4780_990 lab=D[7] dir=inout}
C {devices/lab_pin.sym} 5240 990 0 0 {name=lab_D[8]_5240_990 lab=D[8] dir=inout}
C {devices/lab_pin.sym} 5700 990 0 0 {name=lab_D[9]_5700_990 lab=D[9] dir=inout}
C {devices/lab_pin.sym} 6160 990 0 0 {name=lab_D[10]_6160_990 lab=D[10] dir=inout}
C {devices/lab_pin.sym} 6620 990 0 0 {name=lab_D[11]_6620_990 lab=D[11] dir=inout}
C {devices/lab_pin.sym} 7080 990 0 0 {name=lab_D[12]_7080_990 lab=D[12] dir=inout}
C {devices/lab_pin.sym} 7540 990 0 0 {name=lab_D[13]_7540_990 lab=D[13] dir=inout}
C {devices/lab_pin.sym} 8000 990 0 0 {name=lab_D[14]_8000_990 lab=D[14] dir=inout}
C {devices/lab_pin.sym} 8460 990 0 0 {name=lab_D[15]_8460_990 lab=D[15] dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 1000 0 0 {name=M_0_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 1000 0 0 {name=labB_0_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 1000 0 0 {name=M_0_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 1000 0 0 {name=labB_0_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 1000 0 0 {name=M_0_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 1000 0 0 {name=labB_0_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 1000 0 0 {name=M_0_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 1000 0 0 {name=labB_0_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 1000 0 0 {name=M_0_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 1000 0 0 {name=labB_0_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 1000 0 0 {name=M_0_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 1000 0 0 {name=labB_0_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 1000 0 0 {name=M_0_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 1000 0 0 {name=labB_0_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 1000 0 0 {name=M_0_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 1000 0 0 {name=labB_0_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 1000 0 0 {name=M_0_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 1000 0 0 {name=labB_0_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 1000 0 0 {name=M_0_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 1000 0 0 {name=labB_0_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 1000 0 0 {name=M_0_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 1000 0 0 {name=labB_0_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 1000 0 0 {name=M_0_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 1000 0 0 {name=labB_0_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 1000 0 0 {name=M_0_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 1000 0 0 {name=labB_0_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 1000 0 0 {name=M_0_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 1000 0 0 {name=labB_0_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 1000 0 0 {name=M_0_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 1000 0 0 {name=labB_0_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 1000 0 0 {name=M_0_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 1000 0 0 {name=labB_0_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 1000 0 0 {name=M_0_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 1000 0 0 {name=labB_0_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 1000 0 0 {name=M_0_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 1000 0 0 {name=labB_0_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 1360 0 0 {name=M_1_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 1360 0 0 {name=labB_1_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 1360 0 0 {name=M_1_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 1360 0 0 {name=labB_1_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 1360 0 0 {name=M_1_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 1360 0 0 {name=labB_1_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 1360 0 0 {name=M_1_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 1360 0 0 {name=labB_1_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 1360 0 0 {name=M_1_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 1360 0 0 {name=labB_1_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 1360 0 0 {name=M_1_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 1360 0 0 {name=labB_1_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 1360 0 0 {name=M_1_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 1360 0 0 {name=labB_1_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 1360 0 0 {name=M_1_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 1360 0 0 {name=labB_1_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 1360 0 0 {name=M_1_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 1360 0 0 {name=labB_1_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 1360 0 0 {name=M_1_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 1360 0 0 {name=labB_1_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 1360 0 0 {name=M_1_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 1360 0 0 {name=labB_1_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 1360 0 0 {name=M_1_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 1360 0 0 {name=labB_1_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 1360 0 0 {name=M_1_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 1360 0 0 {name=labB_1_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 1360 0 0 {name=M_1_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 1360 0 0 {name=labB_1_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 1360 0 0 {name=M_1_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 1360 0 0 {name=labB_1_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 1360 0 0 {name=M_1_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 1360 0 0 {name=labB_1_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 1360 0 0 {name=M_1_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 1360 0 0 {name=labB_1_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 1360 0 0 {name=M_1_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 1360 0 0 {name=labB_1_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 1720 0 0 {name=M_2_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 1720 0 0 {name=labB_2_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 1720 0 0 {name=M_2_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 1720 0 0 {name=labB_2_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 1720 0 0 {name=M_2_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 1720 0 0 {name=labB_2_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 1720 0 0 {name=M_2_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 1720 0 0 {name=labB_2_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 1720 0 0 {name=M_2_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 1720 0 0 {name=labB_2_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 1720 0 0 {name=M_2_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 1720 0 0 {name=labB_2_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 1720 0 0 {name=M_2_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 1720 0 0 {name=labB_2_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 1720 0 0 {name=M_2_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 1720 0 0 {name=labB_2_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 1720 0 0 {name=M_2_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 1720 0 0 {name=labB_2_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 1720 0 0 {name=M_2_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 1720 0 0 {name=labB_2_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 1720 0 0 {name=M_2_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 1720 0 0 {name=labB_2_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 1720 0 0 {name=M_2_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 1720 0 0 {name=labB_2_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 1720 0 0 {name=M_2_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 1720 0 0 {name=labB_2_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 1720 0 0 {name=M_2_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 1720 0 0 {name=labB_2_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 1720 0 0 {name=M_2_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 1720 0 0 {name=labB_2_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 1720 0 0 {name=M_2_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 1720 0 0 {name=labB_2_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 1720 0 0 {name=M_2_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 1720 0 0 {name=labB_2_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 1720 0 0 {name=M_2_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 1720 0 0 {name=labB_2_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 2080 0 0 {name=M_3_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 2080 0 0 {name=labB_3_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 2080 0 0 {name=M_3_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 2080 0 0 {name=labB_3_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 2080 0 0 {name=M_3_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 2080 0 0 {name=labB_3_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 2080 0 0 {name=M_3_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 2080 0 0 {name=labB_3_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 2080 0 0 {name=M_3_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 2080 0 0 {name=labB_3_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 2080 0 0 {name=M_3_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 2080 0 0 {name=labB_3_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 2080 0 0 {name=M_3_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 2080 0 0 {name=labB_3_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 2080 0 0 {name=M_3_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 2080 0 0 {name=labB_3_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 2080 0 0 {name=M_3_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 2080 0 0 {name=labB_3_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 2080 0 0 {name=M_3_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 2080 0 0 {name=labB_3_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 2080 0 0 {name=M_3_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 2080 0 0 {name=labB_3_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 2080 0 0 {name=M_3_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 2080 0 0 {name=labB_3_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 2080 0 0 {name=M_3_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 2080 0 0 {name=labB_3_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 2080 0 0 {name=M_3_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 2080 0 0 {name=labB_3_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 2080 0 0 {name=M_3_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 2080 0 0 {name=labB_3_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 2080 0 0 {name=M_3_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 2080 0 0 {name=labB_3_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 2080 0 0 {name=M_3_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 2080 0 0 {name=labB_3_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 2080 0 0 {name=M_3_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 2080 0 0 {name=labB_3_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 2440 0 0 {name=M_4_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 2440 0 0 {name=labB_4_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 2440 0 0 {name=M_4_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 2440 0 0 {name=labB_4_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 2440 0 0 {name=M_4_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 2440 0 0 {name=labB_4_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 2440 0 0 {name=M_4_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 2440 0 0 {name=labB_4_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 2440 0 0 {name=M_4_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 2440 0 0 {name=labB_4_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 2440 0 0 {name=M_4_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 2440 0 0 {name=labB_4_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 2440 0 0 {name=M_4_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 2440 0 0 {name=labB_4_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 2440 0 0 {name=M_4_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 2440 0 0 {name=labB_4_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 2440 0 0 {name=M_4_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 2440 0 0 {name=labB_4_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 2440 0 0 {name=M_4_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 2440 0 0 {name=labB_4_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 2440 0 0 {name=M_4_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 2440 0 0 {name=labB_4_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 2440 0 0 {name=M_4_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 2440 0 0 {name=labB_4_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 2440 0 0 {name=M_4_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 2440 0 0 {name=labB_4_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 2440 0 0 {name=M_4_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 2440 0 0 {name=labB_4_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 2440 0 0 {name=M_4_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 2440 0 0 {name=labB_4_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 2440 0 0 {name=M_4_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 2440 0 0 {name=labB_4_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 2440 0 0 {name=M_4_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 2440 0 0 {name=labB_4_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 2440 0 0 {name=M_4_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 2440 0 0 {name=labB_4_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 2800 0 0 {name=M_5_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 2800 0 0 {name=labB_5_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 2800 0 0 {name=M_5_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 2800 0 0 {name=labB_5_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 2800 0 0 {name=M_5_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 2800 0 0 {name=labB_5_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 2800 0 0 {name=M_5_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 2800 0 0 {name=labB_5_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 2800 0 0 {name=M_5_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 2800 0 0 {name=labB_5_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 2800 0 0 {name=M_5_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 2800 0 0 {name=labB_5_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 2800 0 0 {name=M_5_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 2800 0 0 {name=labB_5_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 2800 0 0 {name=M_5_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 2800 0 0 {name=labB_5_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 2800 0 0 {name=M_5_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 2800 0 0 {name=labB_5_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 2800 0 0 {name=M_5_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 2800 0 0 {name=labB_5_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 2800 0 0 {name=M_5_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 2800 0 0 {name=labB_5_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 2800 0 0 {name=M_5_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 2800 0 0 {name=labB_5_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 2800 0 0 {name=M_5_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 2800 0 0 {name=labB_5_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 2800 0 0 {name=M_5_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 2800 0 0 {name=labB_5_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 2800 0 0 {name=M_5_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 2800 0 0 {name=labB_5_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 2800 0 0 {name=M_5_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 2800 0 0 {name=labB_5_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 2800 0 0 {name=M_5_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 2800 0 0 {name=labB_5_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 2800 0 0 {name=M_5_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 2800 0 0 {name=labB_5_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 3160 0 0 {name=M_6_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 3160 0 0 {name=labB_6_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 3160 0 0 {name=M_6_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 3160 0 0 {name=labB_6_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 3160 0 0 {name=M_6_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 3160 0 0 {name=labB_6_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 3160 0 0 {name=M_6_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 3160 0 0 {name=labB_6_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 3160 0 0 {name=M_6_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 3160 0 0 {name=labB_6_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 3160 0 0 {name=M_6_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 3160 0 0 {name=labB_6_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 3160 0 0 {name=M_6_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 3160 0 0 {name=labB_6_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 3160 0 0 {name=M_6_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 3160 0 0 {name=labB_6_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 3160 0 0 {name=M_6_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 3160 0 0 {name=labB_6_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 3160 0 0 {name=M_6_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 3160 0 0 {name=labB_6_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 3160 0 0 {name=M_6_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 3160 0 0 {name=labB_6_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 3160 0 0 {name=M_6_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 3160 0 0 {name=labB_6_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 3160 0 0 {name=M_6_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 3160 0 0 {name=labB_6_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 3160 0 0 {name=M_6_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 3160 0 0 {name=labB_6_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 3160 0 0 {name=M_6_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 3160 0 0 {name=labB_6_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 3160 0 0 {name=M_6_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 3160 0 0 {name=labB_6_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 3160 0 0 {name=M_6_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 3160 0 0 {name=labB_6_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 3160 0 0 {name=M_6_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 3160 0 0 {name=labB_6_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 3520 0 0 {name=M_7_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 3520 0 0 {name=labB_7_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 3520 0 0 {name=M_7_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 3520 0 0 {name=labB_7_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 3520 0 0 {name=M_7_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 3520 0 0 {name=labB_7_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 3520 0 0 {name=M_7_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 3520 0 0 {name=labB_7_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 3520 0 0 {name=M_7_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 3520 0 0 {name=labB_7_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 3520 0 0 {name=M_7_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 3520 0 0 {name=labB_7_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 3520 0 0 {name=M_7_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 3520 0 0 {name=labB_7_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 3520 0 0 {name=M_7_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 3520 0 0 {name=labB_7_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 3520 0 0 {name=M_7_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 3520 0 0 {name=labB_7_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 3520 0 0 {name=M_7_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 3520 0 0 {name=labB_7_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 3520 0 0 {name=M_7_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 3520 0 0 {name=labB_7_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 3520 0 0 {name=M_7_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 3520 0 0 {name=labB_7_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 3520 0 0 {name=M_7_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 3520 0 0 {name=labB_7_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 3520 0 0 {name=M_7_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 3520 0 0 {name=labB_7_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 3520 0 0 {name=M_7_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 3520 0 0 {name=labB_7_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 3520 0 0 {name=M_7_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 3520 0 0 {name=labB_7_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 3520 0 0 {name=M_7_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 3520 0 0 {name=labB_7_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 3520 0 0 {name=M_7_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 3520 0 0 {name=labB_7_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 3880 0 0 {name=M_8_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 3880 0 0 {name=labB_8_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 3880 0 0 {name=M_8_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 3880 0 0 {name=labB_8_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 3880 0 0 {name=M_8_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 3880 0 0 {name=labB_8_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 3880 0 0 {name=M_8_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 3880 0 0 {name=labB_8_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 3880 0 0 {name=M_8_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 3880 0 0 {name=labB_8_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 3880 0 0 {name=M_8_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 3880 0 0 {name=labB_8_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 3880 0 0 {name=M_8_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 3880 0 0 {name=labB_8_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 3880 0 0 {name=M_8_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 3880 0 0 {name=labB_8_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 3880 0 0 {name=M_8_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 3880 0 0 {name=labB_8_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 3880 0 0 {name=M_8_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 3880 0 0 {name=labB_8_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 3880 0 0 {name=M_8_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 3880 0 0 {name=labB_8_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 3880 0 0 {name=M_8_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 3880 0 0 {name=labB_8_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 3880 0 0 {name=M_8_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 3880 0 0 {name=labB_8_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 3880 0 0 {name=M_8_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 3880 0 0 {name=labB_8_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 3880 0 0 {name=M_8_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 3880 0 0 {name=labB_8_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 3880 0 0 {name=M_8_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 3880 0 0 {name=labB_8_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 3880 0 0 {name=M_8_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 3880 0 0 {name=labB_8_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 3880 0 0 {name=M_8_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 3880 0 0 {name=labB_8_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 4240 0 0 {name=M_9_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 4240 0 0 {name=labB_9_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 4240 0 0 {name=M_9_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 4240 0 0 {name=labB_9_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 4240 0 0 {name=M_9_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 4240 0 0 {name=labB_9_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 4240 0 0 {name=M_9_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 4240 0 0 {name=labB_9_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 4240 0 0 {name=M_9_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 4240 0 0 {name=labB_9_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 4240 0 0 {name=M_9_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 4240 0 0 {name=labB_9_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 4240 0 0 {name=M_9_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 4240 0 0 {name=labB_9_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 4240 0 0 {name=M_9_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 4240 0 0 {name=labB_9_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 4240 0 0 {name=M_9_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 4240 0 0 {name=labB_9_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 4240 0 0 {name=M_9_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 4240 0 0 {name=labB_9_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 4240 0 0 {name=M_9_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 4240 0 0 {name=labB_9_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 4240 0 0 {name=M_9_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 4240 0 0 {name=labB_9_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 4240 0 0 {name=M_9_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 4240 0 0 {name=labB_9_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 4240 0 0 {name=M_9_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 4240 0 0 {name=labB_9_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 4240 0 0 {name=M_9_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 4240 0 0 {name=labB_9_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 4240 0 0 {name=M_9_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 4240 0 0 {name=labB_9_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 4240 0 0 {name=M_9_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 4240 0 0 {name=labB_9_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 4240 0 0 {name=M_9_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 4240 0 0 {name=labB_9_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 4600 0 0 {name=M_10_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 4600 0 0 {name=labB_10_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 4600 0 0 {name=M_10_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 4600 0 0 {name=labB_10_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 4600 0 0 {name=M_10_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 4600 0 0 {name=labB_10_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 4600 0 0 {name=M_10_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 4600 0 0 {name=labB_10_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 4600 0 0 {name=M_10_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 4600 0 0 {name=labB_10_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 4600 0 0 {name=M_10_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 4600 0 0 {name=labB_10_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 4600 0 0 {name=M_10_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 4600 0 0 {name=labB_10_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 4600 0 0 {name=M_10_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 4600 0 0 {name=labB_10_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 4600 0 0 {name=M_10_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 4600 0 0 {name=labB_10_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 4600 0 0 {name=M_10_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 4600 0 0 {name=labB_10_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 4600 0 0 {name=M_10_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 4600 0 0 {name=labB_10_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 4600 0 0 {name=M_10_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 4600 0 0 {name=labB_10_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 4600 0 0 {name=M_10_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 4600 0 0 {name=labB_10_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 4600 0 0 {name=M_10_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 4600 0 0 {name=labB_10_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 4600 0 0 {name=M_10_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 4600 0 0 {name=labB_10_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 4600 0 0 {name=M_10_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 4600 0 0 {name=labB_10_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 4600 0 0 {name=M_10_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 4600 0 0 {name=labB_10_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 4600 0 0 {name=M_10_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 4600 0 0 {name=labB_10_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 4960 0 0 {name=M_11_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 4960 0 0 {name=labB_11_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 4960 0 0 {name=M_11_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 4960 0 0 {name=labB_11_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 4960 0 0 {name=M_11_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 4960 0 0 {name=labB_11_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 4960 0 0 {name=M_11_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 4960 0 0 {name=labB_11_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 4960 0 0 {name=M_11_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 4960 0 0 {name=labB_11_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 4960 0 0 {name=M_11_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 4960 0 0 {name=labB_11_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 4960 0 0 {name=M_11_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 4960 0 0 {name=labB_11_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 4960 0 0 {name=M_11_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 4960 0 0 {name=labB_11_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 4960 0 0 {name=M_11_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 4960 0 0 {name=labB_11_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 4960 0 0 {name=M_11_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 4960 0 0 {name=labB_11_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 4960 0 0 {name=M_11_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 4960 0 0 {name=labB_11_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 4960 0 0 {name=M_11_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 4960 0 0 {name=labB_11_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 4960 0 0 {name=M_11_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 4960 0 0 {name=labB_11_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 4960 0 0 {name=M_11_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 4960 0 0 {name=labB_11_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 4960 0 0 {name=M_11_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 4960 0 0 {name=labB_11_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 4960 0 0 {name=M_11_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 4960 0 0 {name=labB_11_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 4960 0 0 {name=M_11_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 4960 0 0 {name=labB_11_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 4960 0 0 {name=M_11_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 4960 0 0 {name=labB_11_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 5320 0 0 {name=M_12_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 5320 0 0 {name=labB_12_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 5320 0 0 {name=M_12_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 5320 0 0 {name=labB_12_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 5320 0 0 {name=M_12_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 5320 0 0 {name=labB_12_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 5320 0 0 {name=M_12_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 5320 0 0 {name=labB_12_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 5320 0 0 {name=M_12_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 5320 0 0 {name=labB_12_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 5320 0 0 {name=M_12_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 5320 0 0 {name=labB_12_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 5320 0 0 {name=M_12_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 5320 0 0 {name=labB_12_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 5320 0 0 {name=M_12_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 5320 0 0 {name=labB_12_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 5320 0 0 {name=M_12_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 5320 0 0 {name=labB_12_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 5320 0 0 {name=M_12_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 5320 0 0 {name=labB_12_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 5320 0 0 {name=M_12_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 5320 0 0 {name=labB_12_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 5320 0 0 {name=M_12_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 5320 0 0 {name=labB_12_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 5320 0 0 {name=M_12_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 5320 0 0 {name=labB_12_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 5320 0 0 {name=M_12_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 5320 0 0 {name=labB_12_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 5320 0 0 {name=M_12_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 5320 0 0 {name=labB_12_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 5320 0 0 {name=M_12_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 5320 0 0 {name=labB_12_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 5320 0 0 {name=M_12_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 5320 0 0 {name=labB_12_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 5320 0 0 {name=M_12_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 5320 0 0 {name=labB_12_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 5680 0 0 {name=M_13_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 5680 0 0 {name=labB_13_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 5680 0 0 {name=M_13_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 5680 0 0 {name=labB_13_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 5680 0 0 {name=M_13_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 5680 0 0 {name=labB_13_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 5680 0 0 {name=M_13_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 5680 0 0 {name=labB_13_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 5680 0 0 {name=M_13_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 5680 0 0 {name=labB_13_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 5680 0 0 {name=M_13_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 5680 0 0 {name=labB_13_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 5680 0 0 {name=M_13_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 5680 0 0 {name=labB_13_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 5680 0 0 {name=M_13_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 5680 0 0 {name=labB_13_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 5680 0 0 {name=M_13_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 5680 0 0 {name=labB_13_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 5680 0 0 {name=M_13_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 5680 0 0 {name=labB_13_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 5680 0 0 {name=M_13_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 5680 0 0 {name=labB_13_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 5680 0 0 {name=M_13_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 5680 0 0 {name=labB_13_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 5680 0 0 {name=M_13_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 5680 0 0 {name=labB_13_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 5680 0 0 {name=M_13_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 5680 0 0 {name=labB_13_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 5680 0 0 {name=M_13_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 5680 0 0 {name=labB_13_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 5680 0 0 {name=M_13_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 5680 0 0 {name=labB_13_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 5680 0 0 {name=M_13_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 5680 0 0 {name=labB_13_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 5680 0 0 {name=M_13_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 5680 0 0 {name=labB_13_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 6040 0 0 {name=M_14_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 6040 0 0 {name=labB_14_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 6040 0 0 {name=M_14_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 6040 0 0 {name=labB_14_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 6040 0 0 {name=M_14_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 6040 0 0 {name=labB_14_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 6040 0 0 {name=M_14_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 6040 0 0 {name=labB_14_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 6040 0 0 {name=M_14_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 6040 0 0 {name=labB_14_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 6040 0 0 {name=M_14_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 6040 0 0 {name=labB_14_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 6040 0 0 {name=M_14_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 6040 0 0 {name=labB_14_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 6040 0 0 {name=M_14_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 6040 0 0 {name=labB_14_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 6040 0 0 {name=M_14_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 6040 0 0 {name=labB_14_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 6040 0 0 {name=M_14_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 6040 0 0 {name=labB_14_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 6040 0 0 {name=M_14_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 6040 0 0 {name=labB_14_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 6040 0 0 {name=M_14_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 6040 0 0 {name=labB_14_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 6040 0 0 {name=M_14_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 6040 0 0 {name=labB_14_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 6040 0 0 {name=M_14_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 6040 0 0 {name=labB_14_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 6040 0 0 {name=M_14_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 6040 0 0 {name=labB_14_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 6040 0 0 {name=M_14_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 6040 0 0 {name=labB_14_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 6040 0 0 {name=M_14_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 6040 0 0 {name=labB_14_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 6040 0 0 {name=M_14_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 6040 0 0 {name=labB_14_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 6400 0 0 {name=M_15_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 6400 0 0 {name=labB_15_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 6400 0 0 {name=M_15_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 6400 0 0 {name=labB_15_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 6400 0 0 {name=M_15_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 6400 0 0 {name=labB_15_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 6400 0 0 {name=M_15_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 6400 0 0 {name=labB_15_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 6400 0 0 {name=M_15_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 6400 0 0 {name=labB_15_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 6400 0 0 {name=M_15_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 6400 0 0 {name=labB_15_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 6400 0 0 {name=M_15_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 6400 0 0 {name=labB_15_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 6400 0 0 {name=M_15_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 6400 0 0 {name=labB_15_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 6400 0 0 {name=M_15_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 6400 0 0 {name=labB_15_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 6400 0 0 {name=M_15_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 6400 0 0 {name=labB_15_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 6400 0 0 {name=M_15_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 6400 0 0 {name=labB_15_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 6400 0 0 {name=M_15_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 6400 0 0 {name=labB_15_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 6400 0 0 {name=M_15_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 6400 0 0 {name=labB_15_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 6400 0 0 {name=M_15_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 6400 0 0 {name=labB_15_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 6400 0 0 {name=M_15_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 6400 0 0 {name=labB_15_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 6400 0 0 {name=M_15_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 6400 0 0 {name=labB_15_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 6400 0 0 {name=M_15_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 6400 0 0 {name=labB_15_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 6400 0 0 {name=M_15_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 6400 0 0 {name=labB_15_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 6760 0 0 {name=M_16_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 6760 0 0 {name=labB_16_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 6760 0 0 {name=M_16_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 6760 0 0 {name=labB_16_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 6760 0 0 {name=M_16_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 6760 0 0 {name=labB_16_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 6760 0 0 {name=M_16_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 6760 0 0 {name=labB_16_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 6760 0 0 {name=M_16_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 6760 0 0 {name=labB_16_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 6760 0 0 {name=M_16_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 6760 0 0 {name=labB_16_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 6760 0 0 {name=M_16_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 6760 0 0 {name=labB_16_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 6760 0 0 {name=M_16_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 6760 0 0 {name=labB_16_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 6760 0 0 {name=M_16_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 6760 0 0 {name=labB_16_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 6760 0 0 {name=M_16_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 6760 0 0 {name=labB_16_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 6760 0 0 {name=M_16_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 6760 0 0 {name=labB_16_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 6760 0 0 {name=M_16_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 6760 0 0 {name=labB_16_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 6760 0 0 {name=M_16_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 6760 0 0 {name=labB_16_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 6760 0 0 {name=M_16_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 6760 0 0 {name=labB_16_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 6760 0 0 {name=M_16_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 6760 0 0 {name=labB_16_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 6760 0 0 {name=M_16_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 6760 0 0 {name=labB_16_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 6760 0 0 {name=M_16_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 6760 0 0 {name=labB_16_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 6760 0 0 {name=M_16_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 6760 0 0 {name=labB_16_17 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1000 7120 0 0 {name=M_17_0 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1080 7120 0 0 {name=labB_17_0 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1460 7120 0 0 {name=M_17_1 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 1540 7120 0 0 {name=labB_17_1 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 1920 7120 0 0 {name=M_17_2 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2000 7120 0 0 {name=labB_17_2 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2380 7120 0 0 {name=M_17_3 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2460 7120 0 0 {name=labB_17_3 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 2840 7120 0 0 {name=M_17_4 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 2920 7120 0 0 {name=labB_17_4 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3300 7120 0 0 {name=M_17_5 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3380 7120 0 0 {name=labB_17_5 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 3760 7120 0 0 {name=M_17_6 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 3840 7120 0 0 {name=labB_17_6 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4220 7120 0 0 {name=M_17_7 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4300 7120 0 0 {name=labB_17_7 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 4680 7120 0 0 {name=M_17_8 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 4760 7120 0 0 {name=labB_17_8 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5140 7120 0 0 {name=M_17_9 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5220 7120 0 0 {name=labB_17_9 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 5600 7120 0 0 {name=M_17_10 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 5680 7120 0 0 {name=labB_17_10 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 7120 0 0 {name=M_17_11 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6140 7120 0 0 {name=labB_17_11 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6520 7120 0 0 {name=M_17_12 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 6600 7120 0 0 {name=labB_17_12 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 7120 0 0 {name=M_17_13 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7060 7120 0 0 {name=labB_17_13 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7440 7120 0 0 {name=M_17_14 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7520 7120 0 0 {name=labB_17_14 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 7900 7120 0 0 {name=M_17_15 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 7980 7120 0 0 {name=labB_17_15 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8360 7120 0 0 {name=M_17_16 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8440 7120 0 0 {name=labB_17_16 lab=B dir=inout}
C {sg13g2_pr/sg13_lv_nmos.sym} 8820 7120 0 0 {name=M_17_17 w=0.3u l=0.26u ng=1 m=1 model=sg13_lv_nmos}
C {devices/lab_pin.sym} 8900 7120 0 0 {name=labB_17_17 lab=B dir=inout}
