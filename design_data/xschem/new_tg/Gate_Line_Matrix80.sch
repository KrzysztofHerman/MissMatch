spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 91690 -430 2 0 {name=R7_60
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 91240 -1380 0 0 {name=lp_ctrl_p_60__60 lab=ctrl_p[60]}
C {devices/lab_pin.sym} 91290 -1380 0 0 {name=lp_ctrl_n_60__60 lab=ctrl_n[60]}
C {devices/lab_pin.sym} 90890 -570 0 0 {name=lp_Gate_60__60 lab=Gate[60]}
C {devices/lab_pin.sym} 91460 -580 0 0 {name=lp_Source_60__60 lab=Source[60]}
C {sg13g2_pr/sg13_lv_pmos.sym} 92380 -820 0 1 {name=M1_61
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 92170 -820 0 0 {name=M2_61
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 92480 -820 0 0 {name=M3_61
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 92880 -820 0 1 {name=M4_61
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 92670 -820 0 0 {name=M5_61
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 93250 -820 0 1 {name=M6_61
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 93040 -820 0 0 {name=M7_61
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 92230 -430 2 0 {name=R1_61
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 92310 -430 2 0 {name=R2_61
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 92540 -430 2 0 {name=R3_61
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 92730 -430 2 0 {name=R4_61
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 92820 -430 2 0 {name=R5_61
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 93100 -430 2 0 {name=R6_61
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 93190 -430 2 0 {name=R7_61
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 92740 -1380 0 0 {name=lp_ctrl_p_61__61 lab=ctrl_p[61]}
C {devices/lab_pin.sym} 92790 -1380 0 0 {name=lp_ctrl_n_61__61 lab=ctrl_n[61]}
C {devices/lab_pin.sym} 92390 -570 0 0 {name=lp_Gate_61__61 lab=Gate[61]}
C {devices/lab_pin.sym} 92960 -580 0 0 {name=lp_Source_61__61 lab=Source[61]}
C {sg13g2_pr/sg13_lv_pmos.sym} 93880 -820 0 1 {name=M1_62
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 93670 -820 0 0 {name=M2_62
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 93980 -820 0 0 {name=M3_62
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 94380 -820 0 1 {name=M4_62
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 94170 -820 0 0 {name=M5_62
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 94750 -820 0 1 {name=M6_62
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 94540 -820 0 0 {name=M7_62
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 93730 -430 2 0 {name=R1_62
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 93810 -430 2 0 {name=R2_62
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 94040 -430 2 0 {name=R3_62
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 94230 -430 2 0 {name=R4_62
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 94320 -430 2 0 {name=R5_62
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 94600 -430 2 0 {name=R6_62
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 94690 -430 2 0 {name=R7_62
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 94240 -1380 0 0 {name=lp_ctrl_p_62__62 lab=ctrl_p[62]}
C {devices/lab_pin.sym} 94290 -1380 0 0 {name=lp_ctrl_n_62__62 lab=ctrl_n[62]}
C {devices/lab_pin.sym} 93890 -570 0 0 {name=lp_Gate_62__62 lab=Gate[62]}
C {devices/lab_pin.sym} 94460 -580 0 0 {name=lp_Source_62__62 lab=Source[62]}
C {sg13g2_pr/sg13_lv_pmos.sym} 95380 -820 0 1 {name=M1_63
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 95170 -820 0 0 {name=M2_63
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 95480 -820 0 0 {name=M3_63
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 95880 -820 0 1 {name=M4_63
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 95670 -820 0 0 {name=M5_63
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 96250 -820 0 1 {name=M6_63
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 96040 -820 0 0 {name=M7_63
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 95230 -430 2 0 {name=R1_63
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 95310 -430 2 0 {name=R2_63
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 95540 -430 2 0 {name=R3_63
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 95730 -430 2 0 {name=R4_63
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 95820 -430 2 0 {name=R5_63
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 96100 -430 2 0 {name=R6_63
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 96190 -430 2 0 {name=R7_63
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 95740 -1380 0 0 {name=lp_ctrl_p_63__63 lab=ctrl_p[63]}
C {devices/lab_pin.sym} 95790 -1380 0 0 {name=lp_ctrl_n_63__63 lab=ctrl_n[63]}
C {devices/lab_pin.sym} 95390 -570 0 0 {name=lp_Gate_63__63 lab=Gate[63]}
C {devices/lab_pin.sym} 95960 -580 0 0 {name=lp_Source_63__63 lab=Source[63]}
C {sg13g2_pr/sg13_lv_pmos.sym} 96880 -820 0 1 {name=M1_64
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 96670 -820 0 0 {name=M2_64
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 96980 -820 0 0 {name=M3_64
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 97380 -820 0 1 {name=M4_64
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 97170 -820 0 0 {name=M5_64
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 97750 -820 0 1 {name=M6_64
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 97540 -820 0 0 {name=M7_64
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 96730 -430 2 0 {name=R1_64
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 96810 -430 2 0 {name=R2_64
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 97040 -430 2 0 {name=R3_64
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 97230 -430 2 0 {name=R4_64
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 97320 -430 2 0 {name=R5_64
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 97600 -430 2 0 {name=R6_64
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 97690 -430 2 0 {name=R7_64
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 97240 -1380 0 0 {name=lp_ctrl_p_64__64 lab=ctrl_p[64]}
C {devices/lab_pin.sym} 97290 -1380 0 0 {name=lp_ctrl_n_64__64 lab=ctrl_n[64]}
C {devices/lab_pin.sym} 96890 -570 0 0 {name=lp_Gate_64__64 lab=Gate[64]}
C {devices/lab_pin.sym} 97460 -580 0 0 {name=lp_Source_64__64 lab=Source[64]}
C {sg13g2_pr/sg13_lv_pmos.sym} 98380 -820 0 1 {name=M1_65
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 98170 -820 0 0 {name=M2_65
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 98480 -820 0 0 {name=M3_65
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 98880 -820 0 1 {name=M4_65
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 98670 -820 0 0 {name=M5_65
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 99250 -820 0 1 {name=M6_65
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 99040 -820 0 0 {name=M7_65
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 98230 -430 2 0 {name=R1_65
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 98310 -430 2 0 {name=R2_65
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 98540 -430 2 0 {name=R3_65
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 98730 -430 2 0 {name=R4_65
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 98820 -430 2 0 {name=R5_65
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 99100 -430 2 0 {name=R6_65
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 99190 -430 2 0 {name=R7_65
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 98740 -1380 0 0 {name=lp_ctrl_p_65__65 lab=ctrl_p[65]}
C {devices/lab_pin.sym} 98790 -1380 0 0 {name=lp_ctrl_n_65__65 lab=ctrl_n[65]}
C {devices/lab_pin.sym} 98390 -570 0 0 {name=lp_Gate_65__65 lab=Gate[65]}
C {devices/lab_pin.sym} 98960 -580 0 0 {name=lp_Source_65__65 lab=Source[65]}
C {sg13g2_pr/sg13_lv_pmos.sym} 99880 -820 0 1 {name=M1_66
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 99670 -820 0 0 {name=M2_66
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 99980 -820 0 0 {name=M3_66
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 100380 -820 0 1 {name=M4_66
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 100170 -820 0 0 {name=M5_66
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 100750 -820 0 1 {name=M6_66
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 100540 -820 0 0 {name=M7_66
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 99730 -430 2 0 {name=R1_66
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 99810 -430 2 0 {name=R2_66
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 100040 -430 2 0 {name=R3_66
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 100230 -430 2 0 {name=R4_66
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 100320 -430 2 0 {name=R5_66
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 100600 -430 2 0 {name=R6_66
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 100690 -430 2 0 {name=R7_66
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 100240 -1380 0 0 {name=lp_ctrl_p_66__66 lab=ctrl_p[66]}
C {devices/lab_pin.sym} 100290 -1380 0 0 {name=lp_ctrl_n_66__66 lab=ctrl_n[66]}
C {devices/lab_pin.sym} 99890 -570 0 0 {name=lp_Gate_66__66 lab=Gate[66]}
C {devices/lab_pin.sym} 100460 -580 0 0 {name=lp_Source_66__66 lab=Source[66]}
C {sg13g2_pr/sg13_lv_pmos.sym} 101380 -820 0 1 {name=M1_67
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 101170 -820 0 0 {name=M2_67
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 101480 -820 0 0 {name=M3_67
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 101880 -820 0 1 {name=M4_67
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 101670 -820 0 0 {name=M5_67
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 102250 -820 0 1 {name=M6_67
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 102040 -820 0 0 {name=M7_67
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 101230 -430 2 0 {name=R1_67
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 101310 -430 2 0 {name=R2_67
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 101540 -430 2 0 {name=R3_67
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 101730 -430 2 0 {name=R4_67
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 101820 -430 2 0 {name=R5_67
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 102100 -430 2 0 {name=R6_67
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 102190 -430 2 0 {name=R7_67
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 101740 -1380 0 0 {name=lp_ctrl_p_67__67 lab=ctrl_p[67]}
C {devices/lab_pin.sym} 101790 -1380 0 0 {name=lp_ctrl_n_67__67 lab=ctrl_n[67]}
C {devices/lab_pin.sym} 101390 -570 0 0 {name=lp_Gate_67__67 lab=Gate[67]}
C {devices/lab_pin.sym} 101960 -580 0 0 {name=lp_Source_67__67 lab=Source[67]}
C {sg13g2_pr/sg13_lv_pmos.sym} 102880 -820 0 1 {name=M1_68
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 102670 -820 0 0 {name=M2_68
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 102980 -820 0 0 {name=M3_68
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 103380 -820 0 1 {name=M4_68
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 103170 -820 0 0 {name=M5_68
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 103750 -820 0 1 {name=M6_68
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 103540 -820 0 0 {name=M7_68
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 102730 -430 2 0 {name=R1_68
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 102810 -430 2 0 {name=R2_68
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 103040 -430 2 0 {name=R3_68
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 103230 -430 2 0 {name=R4_68
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 103320 -430 2 0 {name=R5_68
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 103600 -430 2 0 {name=R6_68
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 103690 -430 2 0 {name=R7_68
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 103240 -1380 0 0 {name=lp_ctrl_p_68__68 lab=ctrl_p[68]}
C {devices/lab_pin.sym} 103290 -1380 0 0 {name=lp_ctrl_n_68__68 lab=ctrl_n[68]}
C {devices/lab_pin.sym} 102890 -570 0 0 {name=lp_Gate_68__68 lab=Gate[68]}
C {devices/lab_pin.sym} 103460 -580 0 0 {name=lp_Source_68__68 lab=Source[68]}
C {sg13g2_pr/sg13_lv_pmos.sym} 104380 -820 0 1 {name=M1_69
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 104170 -820 0 0 {name=M2_69
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 104480 -820 0 0 {name=M3_69
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 104880 -820 0 1 {name=M4_69
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 104670 -820 0 0 {name=M5_69
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 105250 -820 0 1 {name=M6_69
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 105040 -820 0 0 {name=M7_69
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 104230 -430 2 0 {name=R1_69
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 104310 -430 2 0 {name=R2_69
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 104540 -430 2 0 {name=R3_69
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 104730 -430 2 0 {name=R4_69
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 104820 -430 2 0 {name=R5_69
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 105100 -430 2 0 {name=R6_69
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 105190 -430 2 0 {name=R7_69
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 104740 -1380 0 0 {name=lp_ctrl_p_69__69 lab=ctrl_p[69]}
C {devices/lab_pin.sym} 104790 -1380 0 0 {name=lp_ctrl_n_69__69 lab=ctrl_n[69]}
C {devices/lab_pin.sym} 104390 -570 0 0 {name=lp_Gate_69__69 lab=Gate[69]}
C {devices/lab_pin.sym} 104960 -580 0 0 {name=lp_Source_69__69 lab=Source[69]}
C {sg13g2_pr/sg13_lv_pmos.sym} 105880 -820 0 1 {name=M1_70
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 105670 -820 0 0 {name=M2_70
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 105980 -820 0 0 {name=M3_70
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 106380 -820 0 1 {name=M4_70
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 106170 -820 0 0 {name=M5_70
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 106750 -820 0 1 {name=M6_70
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 106540 -820 0 0 {name=M7_70
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 105730 -430 2 0 {name=R1_70
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 105810 -430 2 0 {name=R2_70
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 106040 -430 2 0 {name=R3_70
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 106230 -430 2 0 {name=R4_70
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 106320 -430 2 0 {name=R5_70
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 106600 -430 2 0 {name=R6_70
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 106690 -430 2 0 {name=R7_70
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 106240 -1380 0 0 {name=lp_ctrl_p_70__70 lab=ctrl_p[70]}
C {devices/lab_pin.sym} 106290 -1380 0 0 {name=lp_ctrl_n_70__70 lab=ctrl_n[70]}
C {devices/lab_pin.sym} 105890 -570 0 0 {name=lp_Gate_70__70 lab=Gate[70]}
C {devices/lab_pin.sym} 106460 -580 0 0 {name=lp_Source_70__70 lab=Source[70]}
C {sg13g2_pr/sg13_lv_pmos.sym} 107380 -820 0 1 {name=M1_71
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 107170 -820 0 0 {name=M2_71
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 107480 -820 0 0 {name=M3_71
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 107880 -820 0 1 {name=M4_71
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 107670 -820 0 0 {name=M5_71
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 108250 -820 0 1 {name=M6_71
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 108040 -820 0 0 {name=M7_71
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 107230 -430 2 0 {name=R1_71
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 107310 -430 2 0 {name=R2_71
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 107540 -430 2 0 {name=R3_71
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 107730 -430 2 0 {name=R4_71
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 107820 -430 2 0 {name=R5_71
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 108100 -430 2 0 {name=R6_71
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 108190 -430 2 0 {name=R7_71
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 107740 -1380 0 0 {name=lp_ctrl_p_71__71 lab=ctrl_p[71]}
C {devices/lab_pin.sym} 107790 -1380 0 0 {name=lp_ctrl_n_71__71 lab=ctrl_n[71]}
C {devices/lab_pin.sym} 107390 -570 0 0 {name=lp_Gate_71__71 lab=Gate[71]}
C {devices/lab_pin.sym} 107960 -580 0 0 {name=lp_Source_71__71 lab=Source[71]}
C {sg13g2_pr/sg13_lv_pmos.sym} 108880 -820 0 1 {name=M1_72
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 108670 -820 0 0 {name=M2_72
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 108980 -820 0 0 {name=M3_72
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 109380 -820 0 1 {name=M4_72
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 109170 -820 0 0 {name=M5_72
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 109750 -820 0 1 {name=M6_72
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 109540 -820 0 0 {name=M7_72
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 108730 -430 2 0 {name=R1_72
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 108810 -430 2 0 {name=R2_72
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 109040 -430 2 0 {name=R3_72
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 109230 -430 2 0 {name=R4_72
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 109320 -430 2 0 {name=R5_72
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 109600 -430 2 0 {name=R6_72
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 109690 -430 2 0 {name=R7_72
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 109240 -1380 0 0 {name=lp_ctrl_p_72__72 lab=ctrl_p[72]}
C {devices/lab_pin.sym} 109290 -1380 0 0 {name=lp_ctrl_n_72__72 lab=ctrl_n[72]}
C {devices/lab_pin.sym} 108890 -570 0 0 {name=lp_Gate_72__72 lab=Gate[72]}
C {devices/lab_pin.sym} 109460 -580 0 0 {name=lp_Source_72__72 lab=Source[72]}
C {sg13g2_pr/sg13_lv_pmos.sym} 110380 -820 0 1 {name=M1_73
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 110170 -820 0 0 {name=M2_73
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 110480 -820 0 0 {name=M3_73
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 110880 -820 0 1 {name=M4_73
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 110670 -820 0 0 {name=M5_73
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 111250 -820 0 1 {name=M6_73
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 111040 -820 0 0 {name=M7_73
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 110230 -430 2 0 {name=R1_73
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 110310 -430 2 0 {name=R2_73
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 110540 -430 2 0 {name=R3_73
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 110730 -430 2 0 {name=R4_73
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 110820 -430 2 0 {name=R5_73
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 111100 -430 2 0 {name=R6_73
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 111190 -430 2 0 {name=R7_73
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 110740 -1380 0 0 {name=lp_ctrl_p_73__73 lab=ctrl_p[73]}
C {devices/lab_pin.sym} 110790 -1380 0 0 {name=lp_ctrl_n_73__73 lab=ctrl_n[73]}
C {devices/lab_pin.sym} 110390 -570 0 0 {name=lp_Gate_73__73 lab=Gate[73]}
C {devices/lab_pin.sym} 110960 -580 0 0 {name=lp_Source_73__73 lab=Source[73]}
C {sg13g2_pr/sg13_lv_pmos.sym} 111880 -820 0 1 {name=M1_74
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 111670 -820 0 0 {name=M2_74
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 111980 -820 0 0 {name=M3_74
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 112380 -820 0 1 {name=M4_74
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 112170 -820 0 0 {name=M5_74
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 112750 -820 0 1 {name=M6_74
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 112540 -820 0 0 {name=M7_74
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 111730 -430 2 0 {name=R1_74
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 111810 -430 2 0 {name=R2_74
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 112040 -430 2 0 {name=R3_74
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 112230 -430 2 0 {name=R4_74
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 112320 -430 2 0 {name=R5_74
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 112600 -430 2 0 {name=R6_74
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 112690 -430 2 0 {name=R7_74
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 112240 -1380 0 0 {name=lp_ctrl_p_74__74 lab=ctrl_p[74]}
C {devices/lab_pin.sym} 112290 -1380 0 0 {name=lp_ctrl_n_74__74 lab=ctrl_n[74]}
C {devices/lab_pin.sym} 111890 -570 0 0 {name=lp_Gate_74__74 lab=Gate[74]}
C {devices/lab_pin.sym} 112460 -580 0 0 {name=lp_Source_74__74 lab=Source[74]}
C {sg13g2_pr/sg13_lv_pmos.sym} 113380 -820 0 1 {name=M1_75
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 113170 -820 0 0 {name=M2_75
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 113480 -820 0 0 {name=M3_75
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 113880 -820 0 1 {name=M4_75
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 113670 -820 0 0 {name=M5_75
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 114250 -820 0 1 {name=M6_75
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 114040 -820 0 0 {name=M7_75
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 113230 -430 2 0 {name=R1_75
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 113310 -430 2 0 {name=R2_75
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 113540 -430 2 0 {name=R3_75
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 113730 -430 2 0 {name=R4_75
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 113820 -430 2 0 {name=R5_75
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 114100 -430 2 0 {name=R6_75
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 114190 -430 2 0 {name=R7_75
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 113740 -1380 0 0 {name=lp_ctrl_p_75__75 lab=ctrl_p[75]}
C {devices/lab_pin.sym} 113790 -1380 0 0 {name=lp_ctrl_n_75__75 lab=ctrl_n[75]}
C {devices/lab_pin.sym} 113390 -570 0 0 {name=lp_Gate_75__75 lab=Gate[75]}
C {devices/lab_pin.sym} 113960 -580 0 0 {name=lp_Source_75__75 lab=Source[75]}
C {sg13g2_pr/sg13_lv_pmos.sym} 114880 -820 0 1 {name=M1_76
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 114670 -820 0 0 {name=M2_76
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 114980 -820 0 0 {name=M3_76
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 115380 -820 0 1 {name=M4_76
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 115170 -820 0 0 {name=M5_76
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 115750 -820 0 1 {name=M6_76
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 115540 -820 0 0 {name=M7_76
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 114730 -430 2 0 {name=R1_76
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 114810 -430 2 0 {name=R2_76
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 115040 -430 2 0 {name=R3_76
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 115230 -430 2 0 {name=R4_76
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 115320 -430 2 0 {name=R5_76
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 115600 -430 2 0 {name=R6_76
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 115690 -430 2 0 {name=R7_76
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 115240 -1380 0 0 {name=lp_ctrl_p_76__76 lab=ctrl_p[76]}
C {devices/lab_pin.sym} 115290 -1380 0 0 {name=lp_ctrl_n_76__76 lab=ctrl_n[76]}
C {devices/lab_pin.sym} 114890 -570 0 0 {name=lp_Gate_76__76 lab=Gate[76]}
C {devices/lab_pin.sym} 115460 -580 0 0 {name=lp_Source_76__76 lab=Source[76]}
C {sg13g2_pr/sg13_lv_pmos.sym} 116380 -820 0 1 {name=M1_77
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 116170 -820 0 0 {name=M2_77
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 116480 -820 0 0 {name=M3_77
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 116880 -820 0 1 {name=M4_77
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 116670 -820 0 0 {name=M5_77
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 117250 -820 0 1 {name=M6_77
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 117040 -820 0 0 {name=M7_77
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 116230 -430 2 0 {name=R1_77
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 116310 -430 2 0 {name=R2_77
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 116540 -430 2 0 {name=R3_77
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 116730 -430 2 0 {name=R4_77
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 116820 -430 2 0 {name=R5_77
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 117100 -430 2 0 {name=R6_77
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 117190 -430 2 0 {name=R7_77
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 116740 -1380 0 0 {name=lp_ctrl_p_77__77 lab=ctrl_p[77]}
C {devices/lab_pin.sym} 116790 -1380 0 0 {name=lp_ctrl_n_77__77 lab=ctrl_n[77]}
C {devices/lab_pin.sym} 116390 -570 0 0 {name=lp_Gate_77__77 lab=Gate[77]}
C {devices/lab_pin.sym} 116960 -580 0 0 {name=lp_Source_77__77 lab=Source[77]}
C {sg13g2_pr/sg13_lv_pmos.sym} 117880 -820 0 1 {name=M1_78
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 117670 -820 0 0 {name=M2_78
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 117980 -820 0 0 {name=M3_78
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 118380 -820 0 1 {name=M4_78
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 118170 -820 0 0 {name=M5_78
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 118750 -820 0 1 {name=M6_78
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 118540 -820 0 0 {name=M7_78
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 117730 -430 2 0 {name=R1_78
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 117810 -430 2 0 {name=R2_78
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 118040 -430 2 0 {name=R3_78
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 118230 -430 2 0 {name=R4_78
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 118320 -430 2 0 {name=R5_78
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 118600 -430 2 0 {name=R6_78
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 118690 -430 2 0 {name=R7_78
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 118240 -1380 0 0 {name=lp_ctrl_p_78__78 lab=ctrl_p[78]}
C {devices/lab_pin.sym} 118290 -1380 0 0 {name=lp_ctrl_n_78__78 lab=ctrl_n[78]}
C {devices/lab_pin.sym} 117890 -570 0 0 {name=lp_Gate_78__78 lab=Gate[78]}
C {devices/lab_pin.sym} 118460 -580 0 0 {name=lp_Source_78__78 lab=Source[78]}
C {sg13g2_pr/sg13_lv_pmos.sym} 119380 -820 0 1 {name=M1_79
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 119170 -820 0 0 {name=M2_79
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 119480 -820 0 0 {name=M3_79
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 119880 -820 0 1 {name=M4_79
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 119670 -820 0 0 {name=M5_79
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 120250 -820 0 1 {name=M6_79
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 120040 -820 0 0 {name=M7_79
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 119230 -430 2 0 {name=R1_79
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 119310 -430 2 0 {name=R2_79
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 119540 -430 2 0 {name=R3_79
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 119730 -430 2 0 {name=R4_79
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 119820 -430 2 0 {name=R5_79
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 120100 -430 2 0 {name=R6_79
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 120190 -430 2 0 {name=R7_79
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 119740 -1380 0 0 {name=lp_ctrl_p_79__79 lab=ctrl_p[79]}
C {devices/lab_pin.sym} 119790 -1380 0 0 {name=lp_ctrl_n_79__79 lab=ctrl_n[79]}
C {devices/lab_pin.sym} 119390 -570 0 0 {name=lp_Gate_79__79 lab=Gate[79]}
C {devices/lab_pin.sym} 119960 -580 0 0 {name=lp_Source_79__79 lab=Source[79]}
C {devices/iopin.sym} -100 -1370 0 0 {name=p_ctrl_n lab=ctrl_n[0:79]  dir=inout}
C {devices/iopin.sym} -100 -1400 0 0 {name=p_ctrl_p lab=ctrl_p[0:79] dir=inout
}
C {devices/iopin.sym} -100 -1340 0 0 {name=p_source lab=Source[0:79] dir=inout}
C {devices/iopin.sym} -100 -1310 0 0 {name=p_gate lab=Gate[0:79] dir=inout}
