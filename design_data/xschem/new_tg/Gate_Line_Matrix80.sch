v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 1000 -1230 2500 -1230 {lab=Vcl}
N 780 -1200 2280 -1200 {lab=Gdrive}
N 1280 -1170 2780 -1170 {lab=Ssense}
N 1650 -1140 3150 -1140 {lab=Sforce}
N 1870 -1110 3370 -1110 {lab=1.2V}
N 1900 -1080 3400 -1080 {lab=Vss}
N 690 -960 690 -850 {lab=Gdrive}
N 780 -960 860 -960 {lab=Gdrive}
N 860 -960 860 -850 {lab=Gdrive}
N 690 -790 690 -700 {lab=Gate[0]}
N 780 -700 860 -700 {lab=Gate[0]}
N 860 -790 860 -700 {lab=Gate[0]}
N 1000 -790 1000 -650 {lab=Gate[0]}
N 890 -650 1000 -650 {lab=Gate[0]}
N 780 -700 780 -650 {lab=Gate[0]}
N 690 -700 780 -700 {lab=Gate[0]}
N 890 -650 890 -570 {lab=Gate[0]}
N 780 -650 890 -650 {lab=Gate[0]}
N 940 -820 960 -820 {lab=ctrl_n[0]}
N 1190 -960 1190 -850 {lab=Ssense}
N 1280 -960 1360 -960 {lab=Ssense}
N 1360 -960 1360 -850 {lab=Ssense}
N 1190 -790 1190 -700 {lab=Source[0]}
N 1280 -700 1360 -700 {lab=Source[0]}
N 1360 -790 1360 -700 {lab=Source[0]}
N 1280 -700 1280 -650 {lab=Source[0]}
N 1190 -700 1280 -700 {lab=Source[0]}
N 1560 -960 1560 -850 {lab=Sforce}
N 1650 -960 1730 -960 {lab=Sforce}
N 1730 -960 1730 -850 {lab=Sforce}
N 1560 -790 1560 -700 {lab=Source[0]}
N 1650 -700 1730 -700 {lab=Source[0]}
N 1730 -790 1730 -700 {lab=Source[0]}
N 1650 -700 1650 -650 {lab=Source[0]}
N 1560 -700 1650 -700 {lab=Source[0]}
N 1460 -650 1650 -650 {lab=Source[0]}
N 1650 -1140 1650 -960 {lab=Sforce}
N 1560 -960 1650 -960 {lab=Sforce}
N 1280 -1170 1280 -960 {lab=Ssense}
N 1190 -960 1280 -960 {lab=Ssense}
N 780 -1200 780 -960 {lab=Gdrive}
N 690 -960 780 -960 {lab=Gdrive}
N 1000 -1230 1000 -850 {lab=Vcl}
N 1240 -1380 1240 -1350 {lab=ctrl_p[0]}
N 1110 -1350 1240 -1350 {lab=ctrl_p[0]}
N 610 -1350 610 -820 {lab=ctrl_p[0]}
N 610 -820 650 -820 {lab=ctrl_p[0]}
N 1110 -820 1150 -820 {lab=ctrl_p[0]}
N 1110 -1350 1110 -820 {lab=ctrl_p[0]}
N 610 -1350 1110 -1350 {lab=ctrl_p[0]}
N 940 -1320 940 -820 {lab=ctrl_n[0]}
N 900 -820 940 -820 {lab=ctrl_n[0]}
N 940 -1320 1290 -1320 {lab=ctrl_n[0]}
N 1290 -1380 1290 -1320 {lab=ctrl_n[0]}
N 1400 -820 1440 -820 {lab=ctrl_n[0]}
N 1480 -820 1520 -820 {lab=ctrl_p[0]}
N 1440 -1320 1800 -1320 {lab=ctrl_n[0]}
N 1440 -1320 1440 -820 {lab=ctrl_n[0]}
N 1290 -1320 1440 -1320 {lab=ctrl_n[0]}
N 1240 -1350 1480 -1350 {lab=ctrl_p[0]}
N 1480 -1350 1480 -820 {lab=ctrl_p[0]}
N 1800 -1320 1800 -820 {lab=ctrl_n[0]}
N 1770 -820 1800 -820 {lab=ctrl_n[0]}
N 1460 -650 1460 -580 {lab=Source[0]}
N 1280 -650 1460 -650 {lab=Source[0]}
N 690 -820 730 -820 {lab=#net1}
N 730 -820 730 -460 {lab=#net1}
N 1000 -820 1040 -820 {lab=#net2}
N 1040 -820 1040 -460 {lab=#net2}
N 730 -400 730 -330 {lab=Vss}
N 1600 -330 1900 -330 {lab=Vss}
N 1900 -1080 1900 -330 {lab=Vss}
N 1870 -1110 1870 -360 {lab=1.2V}
N 1040 -400 1040 -330 {lab=Vss}
N 730 -330 1040 -330 {lab=Vss}
N 1690 -360 1870 -360 {lab=1.2V}
N 1320 -820 1360 -820 {lab=#net3}
N 1320 -820 1320 -460 {lab=#net3}
N 1190 -820 1230 -820 {lab=#net4}
N 1230 -820 1230 -460 {lab=#net4}
N 1320 -400 1320 -360 {lab=1.2V}
N 1230 -400 1230 -330 {lab=Vss}
N 1040 -330 1230 -330 {lab=Vss}
N 810 -820 860 -820 {lab=#net5}
N 810 -820 810 -460 {lab=#net5}
N 810 -400 810 -360 {lab=1.2V}
N 810 -360 1320 -360 {lab=1.2V}
N 1560 -820 1600 -820 {lab=#net6}
N 1600 -820 1600 -460 {lab=#net6}
N 1690 -820 1730 -820 {lab=#net7}
N 1690 -820 1690 -460 {lab=#net7}
N 1690 -400 1690 -360 {lab=1.2V}
N 1320 -360 1690 -360 {lab=1.2V}
N 1600 -400 1600 -330 {lab=Vss}
N 1230 -330 1600 -330 {lab=Vss}
N 2190 -960 2190 -850 {lab=Gdrive}
N 2280 -960 2360 -960 {lab=Gdrive}
N 2360 -960 2360 -850 {lab=Gdrive}
N 2190 -790 2190 -700 {lab=Gate[1]}
N 2280 -700 2360 -700 {lab=Gate[1]}
N 2360 -790 2360 -700 {lab=Gate[1]}
N 2500 -790 2500 -650 {lab=Gate[1]}
N 2390 -650 2500 -650 {lab=Gate[1]}
N 2280 -700 2280 -650 {lab=Gate[1]}
N 2190 -700 2280 -700 {lab=Gate[1]}
N 2390 -650 2390 -570 {lab=Gate[1]}
N 2280 -650 2390 -650 {lab=Gate[1]}
N 2440 -820 2460 -820 {lab=ctrl_n[1]}
N 2690 -960 2690 -850 {lab=Ssense}
N 2780 -960 2860 -960 {lab=Ssense}
N 2860 -960 2860 -850 {lab=Ssense}
N 2690 -790 2690 -700 {lab=Source[1]}
N 2780 -700 2860 -700 {lab=Source[1]}
N 2860 -790 2860 -700 {lab=Source[1]}
N 2780 -700 2780 -650 {lab=Source[1]}
N 2690 -700 2780 -700 {lab=Source[1]}
N 3060 -960 3060 -850 {lab=Sforce}
N 3150 -960 3230 -960 {lab=Sforce}
N 3230 -960 3230 -850 {lab=Sforce}
N 3060 -790 3060 -700 {lab=Source[1]}
N 3150 -700 3230 -700 {lab=Source[1]}
N 3230 -790 3230 -700 {lab=Source[1]}
N 3150 -700 3150 -650 {lab=Source[1]}
N 3060 -700 3150 -700 {lab=Source[1]}
N 2960 -650 3150 -650 {lab=Source[1]}
N 3150 -1140 4650 -1140 {lab=Sforce}
N 3150 -1140 3150 -960 {lab=Sforce}
N 3060 -960 3150 -960 {lab=Sforce}
N 2780 -1170 4280 -1170 {lab=Ssense}
N 2780 -1170 2780 -960 {lab=Ssense}
N 2690 -960 2780 -960 {lab=Ssense}
N 2280 -1200 3780 -1200 {lab=Gdrive}
N 2280 -1200 2280 -960 {lab=Gdrive}
N 2190 -960 2280 -960 {lab=Gdrive}
N 2500 -1230 4000 -1230 {lab=Vcl}
N 2500 -1230 2500 -850 {lab=Vcl}
N 2740 -1380 2740 -1350 {lab=ctrl_p[1]}
N 2610 -1350 2740 -1350 {lab=ctrl_p[1]}
N 2110 -1350 2110 -820 {lab=ctrl_p[1]}
N 2110 -820 2150 -820 {lab=ctrl_p[1]}
N 2610 -820 2650 -820 {lab=ctrl_p[1]}
N 2610 -1350 2610 -820 {lab=ctrl_p[1]}
N 2110 -1350 2610 -1350 {lab=ctrl_p[1]}
N 2440 -1320 2440 -820 {lab=ctrl_n[1]}
N 2400 -820 2440 -820 {lab=ctrl_n[1]}
N 2440 -1320 2790 -1320 {lab=ctrl_n[1]}
N 2790 -1380 2790 -1320 {lab=ctrl_n[1]}
N 2900 -820 2940 -820 {lab=ctrl_n[1]}
N 2980 -820 3020 -820 {lab=ctrl_p[1]}
N 2940 -1320 3300 -1320 {lab=ctrl_n[1]}
N 2940 -1320 2940 -820 {lab=ctrl_n[1]}
N 2790 -1320 2940 -1320 {lab=ctrl_n[1]}
N 2740 -1350 2980 -1350 {lab=ctrl_p[1]}
N 2980 -1350 2980 -820 {lab=ctrl_p[1]}
N 3300 -1320 3300 -820 {lab=ctrl_n[1]}
N 3270 -820 3300 -820 {lab=ctrl_n[1]}
N 2960 -650 2960 -580 {lab=Source[1]}
N 2780 -650 2960 -650 {lab=Source[1]}
N 2190 -820 2230 -820 {lab=#net8}
N 2230 -820 2230 -460 {lab=#net8}
N 2500 -820 2540 -820 {lab=#net9}
N 2540 -820 2540 -460 {lab=#net9}
N 2230 -400 2230 -330 {lab=Vss}
N 3100 -330 3400 -330 {lab=Vss}
N 3400 -1080 3400 -330 {lab=Vss}
N 3400 -1080 4900 -1080 {lab=Vss}
N 3370 -1110 4870 -1110 {lab=1.2V}
N 3370 -1110 3370 -360 {lab=1.2V}
N 2540 -400 2540 -330 {lab=Vss}
N 2230 -330 2540 -330 {lab=Vss}
N 3190 -360 3370 -360 {lab=1.2V}
N 2820 -820 2860 -820 {lab=#net10}
N 2820 -820 2820 -460 {lab=#net10}
N 2690 -820 2730 -820 {lab=#net11}
N 2730 -820 2730 -460 {lab=#net11}
N 2820 -400 2820 -360 {lab=1.2V}
N 2730 -400 2730 -330 {lab=Vss}
N 2540 -330 2730 -330 {lab=Vss}
N 2310 -820 2360 -820 {lab=#net12}
N 2310 -820 2310 -460 {lab=#net12}
N 2310 -400 2310 -360 {lab=1.2V}
N 2310 -360 2820 -360 {lab=1.2V}
N 3060 -820 3100 -820 {lab=#net13}
N 3100 -820 3100 -460 {lab=#net13}
N 3190 -820 3230 -820 {lab=#net14}
N 3190 -820 3190 -460 {lab=#net14}
N 3190 -400 3190 -360 {lab=1.2V}
N 2820 -360 3190 -360 {lab=1.2V}
N 3100 -400 3100 -330 {lab=Vss}
N 2730 -330 3100 -330 {lab=Vss}
N 3690 -960 3690 -850 {lab=Gdrive}
N 3780 -960 3860 -960 {lab=Gdrive}
N 3860 -960 3860 -850 {lab=Gdrive}
N 3690 -790 3690 -700 {lab=Gate[2]}
N 3780 -700 3860 -700 {lab=Gate[2]}
N 3860 -790 3860 -700 {lab=Gate[2]}
N 4000 -790 4000 -650 {lab=Gate[2]}
N 3890 -650 4000 -650 {lab=Gate[2]}
N 3780 -700 3780 -650 {lab=Gate[2]}
N 3690 -700 3780 -700 {lab=Gate[2]}
N 3890 -650 3890 -570 {lab=Gate[2]}
N 3780 -650 3890 -650 {lab=Gate[2]}
N 3940 -820 3960 -820 {lab=ctrl_n[2]}
N 4190 -960 4190 -850 {lab=Ssense}
N 4280 -960 4360 -960 {lab=Ssense}
N 4360 -960 4360 -850 {lab=Ssense}
N 4190 -790 4190 -700 {lab=Source[2]}
N 4280 -700 4360 -700 {lab=Source[2]}
N 4360 -790 4360 -700 {lab=Source[2]}
N 4280 -700 4280 -650 {lab=Source[2]}
N 4190 -700 4280 -700 {lab=Source[2]}
N 4560 -960 4560 -850 {lab=Sforce}
N 4650 -960 4730 -960 {lab=Sforce}
N 4730 -960 4730 -850 {lab=Sforce}
N 4560 -790 4560 -700 {lab=Source[2]}
N 4650 -700 4730 -700 {lab=Source[2]}
N 4730 -790 4730 -700 {lab=Source[2]}
N 4650 -700 4650 -650 {lab=Source[2]}
N 4560 -700 4650 -700 {lab=Source[2]}
N 4460 -650 4650 -650 {lab=Source[2]}
N 4650 -1140 6150 -1140 {lab=Sforce}
N 4650 -1140 4650 -960 {lab=Sforce}
N 4560 -960 4650 -960 {lab=Sforce}
N 4280 -1170 5780 -1170 {lab=Ssense}
N 4280 -1170 4280 -960 {lab=Ssense}
N 4190 -960 4280 -960 {lab=Ssense}
N 3780 -1200 5280 -1200 {lab=Gdrive}
N 3780 -1200 3780 -960 {lab=Gdrive}
N 3690 -960 3780 -960 {lab=Gdrive}
N 4000 -1230 5500 -1230 {lab=Vcl}
N 4000 -1230 4000 -850 {lab=Vcl}
N 4240 -1380 4240 -1350 {lab=ctrl_p[2]}
N 4110 -1350 4240 -1350 {lab=ctrl_p[2]}
N 3610 -1350 3610 -820 {lab=ctrl_p[2]}
N 3610 -820 3650 -820 {lab=ctrl_p[2]}
N 4110 -820 4150 -820 {lab=ctrl_p[2]}
N 4110 -1350 4110 -820 {lab=ctrl_p[2]}
N 3610 -1350 4110 -1350 {lab=ctrl_p[2]}
N 3940 -1320 3940 -820 {lab=ctrl_n[2]}
N 3900 -820 3940 -820 {lab=ctrl_n[2]}
N 3940 -1320 4290 -1320 {lab=ctrl_n[2]}
N 4290 -1380 4290 -1320 {lab=ctrl_n[2]}
N 4400 -820 4440 -820 {lab=ctrl_n[2]}
N 4480 -820 4520 -820 {lab=ctrl_p[2]}
N 4440 -1320 4800 -1320 {lab=ctrl_n[2]}
N 4440 -1320 4440 -820 {lab=ctrl_n[2]}
N 4290 -1320 4440 -1320 {lab=ctrl_n[2]}
N 4240 -1350 4480 -1350 {lab=ctrl_p[2]}
N 4480 -1350 4480 -820 {lab=ctrl_p[2]}
N 4800 -1320 4800 -820 {lab=ctrl_n[2]}
N 4770 -820 4800 -820 {lab=ctrl_n[2]}
N 4460 -650 4460 -580 {lab=Source[2]}
N 4280 -650 4460 -650 {lab=Source[2]}
N 3690 -820 3730 -820 {lab=#net15}
N 3730 -820 3730 -460 {lab=#net15}
N 4000 -820 4040 -820 {lab=#net16}
N 4040 -820 4040 -460 {lab=#net16}
N 3730 -400 3730 -330 {lab=Vss}
N 4600 -330 4900 -330 {lab=Vss}
N 4900 -1080 4900 -330 {lab=Vss}
N 4900 -1080 6400 -1080 {lab=Vss}
N 4870 -1110 6370 -1110 {lab=1.2V}
N 4870 -1110 4870 -360 {lab=1.2V}
N 4040 -400 4040 -330 {lab=Vss}
N 3730 -330 4040 -330 {lab=Vss}
N 4690 -360 4870 -360 {lab=1.2V}
N 4320 -820 4360 -820 {lab=#net17}
N 4320 -820 4320 -460 {lab=#net17}
N 4190 -820 4230 -820 {lab=#net18}
N 4230 -820 4230 -460 {lab=#net18}
N 4320 -400 4320 -360 {lab=1.2V}
N 4230 -400 4230 -330 {lab=Vss}
N 4040 -330 4230 -330 {lab=Vss}
N 3810 -820 3860 -820 {lab=#net19}
N 3810 -820 3810 -460 {lab=#net19}
N 3810 -400 3810 -360 {lab=1.2V}
N 3810 -360 4320 -360 {lab=1.2V}
N 4560 -820 4600 -820 {lab=#net20}
N 4600 -820 4600 -460 {lab=#net20}
N 4690 -820 4730 -820 {lab=#net21}
N 4690 -820 4690 -460 {lab=#net21}
N 4690 -400 4690 -360 {lab=1.2V}
N 4320 -360 4690 -360 {lab=1.2V}
N 4600 -400 4600 -330 {lab=Vss}
N 4230 -330 4600 -330 {lab=Vss}
N 5190 -960 5190 -850 {lab=Gdrive}
N 5280 -960 5360 -960 {lab=Gdrive}
N 5360 -960 5360 -850 {lab=Gdrive}
N 5190 -790 5190 -700 {lab=Gate[3]}
N 5280 -700 5360 -700 {lab=Gate[3]}
N 5360 -790 5360 -700 {lab=Gate[3]}
N 5500 -790 5500 -650 {lab=Gate[3]}
N 5390 -650 5500 -650 {lab=Gate[3]}
N 5280 -700 5280 -650 {lab=Gate[3]}
N 5190 -700 5280 -700 {lab=Gate[3]}
N 5390 -650 5390 -570 {lab=Gate[3]}
N 5280 -650 5390 -650 {lab=Gate[3]}
N 5440 -820 5460 -820 {lab=ctrl_n[3]}
N 5690 -960 5690 -850 {lab=Ssense}
N 5780 -960 5860 -960 {lab=Ssense}
N 5860 -960 5860 -850 {lab=Ssense}
N 5690 -790 5690 -700 {lab=Source[3]}
N 5780 -700 5860 -700 {lab=Source[3]}
N 5860 -790 5860 -700 {lab=Source[3]}
N 5780 -700 5780 -650 {lab=Source[3]}
N 5690 -700 5780 -700 {lab=Source[3]}
N 6060 -960 6060 -850 {lab=Sforce}
N 6150 -960 6230 -960 {lab=Sforce}
N 6230 -960 6230 -850 {lab=Sforce}
N 6060 -790 6060 -700 {lab=Source[3]}
N 6150 -700 6230 -700 {lab=Source[3]}
N 6230 -790 6230 -700 {lab=Source[3]}
N 6150 -700 6150 -650 {lab=Source[3]}
N 6060 -700 6150 -700 {lab=Source[3]}
N 5960 -650 6150 -650 {lab=Source[3]}
N 6150 -1140 7650 -1140 {lab=Sforce}
N 6150 -1140 6150 -960 {lab=Sforce}
N 6060 -960 6150 -960 {lab=Sforce}
N 5780 -1170 7280 -1170 {lab=Ssense}
N 5780 -1170 5780 -960 {lab=Ssense}
N 5690 -960 5780 -960 {lab=Ssense}
N 5280 -1200 6780 -1200 {lab=Gdrive}
N 5280 -1200 5280 -960 {lab=Gdrive}
N 5190 -960 5280 -960 {lab=Gdrive}
N 5500 -1230 7000 -1230 {lab=Vcl}
N 5500 -1230 5500 -850 {lab=Vcl}
N 5740 -1380 5740 -1350 {lab=ctrl_p[3]}
N 5610 -1350 5740 -1350 {lab=ctrl_p[3]}
N 5110 -1350 5110 -820 {lab=ctrl_p[3]}
N 5110 -820 5150 -820 {lab=ctrl_p[3]}
N 5610 -820 5650 -820 {lab=ctrl_p[3]}
N 5610 -1350 5610 -820 {lab=ctrl_p[3]}
N 5110 -1350 5610 -1350 {lab=ctrl_p[3]}
N 5440 -1320 5440 -820 {lab=ctrl_n[3]}
N 5400 -820 5440 -820 {lab=ctrl_n[3]}
N 5440 -1320 5790 -1320 {lab=ctrl_n[3]}
N 5790 -1380 5790 -1320 {lab=ctrl_n[3]}
N 5900 -820 5940 -820 {lab=ctrl_n[3]}
N 5980 -820 6020 -820 {lab=ctrl_p[3]}
N 5940 -1320 6300 -1320 {lab=ctrl_n[3]}
N 5940 -1320 5940 -820 {lab=ctrl_n[3]}
N 5790 -1320 5940 -1320 {lab=ctrl_n[3]}
N 5740 -1350 5980 -1350 {lab=ctrl_p[3]}
N 5980 -1350 5980 -820 {lab=ctrl_p[3]}
N 6300 -1320 6300 -820 {lab=ctrl_n[3]}
N 6270 -820 6300 -820 {lab=ctrl_n[3]}
N 5960 -650 5960 -580 {lab=Source[3]}
N 5780 -650 5960 -650 {lab=Source[3]}
N 5190 -820 5230 -820 {lab=#net22}
N 5230 -820 5230 -460 {lab=#net22}
N 5500 -820 5540 -820 {lab=#net23}
N 5540 -820 5540 -460 {lab=#net23}
N 5230 -400 5230 -330 {lab=Vss}
N 6100 -330 6400 -330 {lab=Vss}
N 6400 -1080 6400 -330 {lab=Vss}
N 6400 -1080 7900 -1080 {lab=Vss}
N 6370 -1110 7870 -1110 {lab=1.2V}
N 6370 -1110 6370 -360 {lab=1.2V}
N 5540 -400 5540 -330 {lab=Vss}
N 5230 -330 5540 -330 {lab=Vss}
N 6190 -360 6370 -360 {lab=1.2V}
N 5820 -820 5860 -820 {lab=#net24}
N 5820 -820 5820 -460 {lab=#net24}
N 5690 -820 5730 -820 {lab=#net25}
N 5730 -820 5730 -460 {lab=#net25}
N 5820 -400 5820 -360 {lab=1.2V}
N 5730 -400 5730 -330 {lab=Vss}
N 5540 -330 5730 -330 {lab=Vss}
N 5310 -820 5360 -820 {lab=#net26}
N 5310 -820 5310 -460 {lab=#net26}
N 5310 -400 5310 -360 {lab=1.2V}
N 5310 -360 5820 -360 {lab=1.2V}
N 6060 -820 6100 -820 {lab=#net27}
N 6100 -820 6100 -460 {lab=#net27}
N 6190 -820 6230 -820 {lab=#net28}
N 6190 -820 6190 -460 {lab=#net28}
N 6190 -400 6190 -360 {lab=1.2V}
N 5820 -360 6190 -360 {lab=1.2V}
N 6100 -400 6100 -330 {lab=Vss}
N 5730 -330 6100 -330 {lab=Vss}
N 6690 -960 6690 -850 {lab=Gdrive}
N 6780 -960 6860 -960 {lab=Gdrive}
N 6860 -960 6860 -850 {lab=Gdrive}
N 6690 -790 6690 -700 {lab=Gate[4]}
N 6780 -700 6860 -700 {lab=Gate[4]}
N 6860 -790 6860 -700 {lab=Gate[4]}
N 7000 -790 7000 -650 {lab=Gate[4]}
N 6890 -650 7000 -650 {lab=Gate[4]}
N 6780 -700 6780 -650 {lab=Gate[4]}
N 6690 -700 6780 -700 {lab=Gate[4]}
N 6890 -650 6890 -570 {lab=Gate[4]}
N 6780 -650 6890 -650 {lab=Gate[4]}
N 6940 -820 6960 -820 {lab=ctrl_n[4]}
N 7190 -960 7190 -850 {lab=Ssense}
N 7280 -960 7360 -960 {lab=Ssense}
N 7360 -960 7360 -850 {lab=Ssense}
N 7190 -790 7190 -700 {lab=Source[4]}
N 7280 -700 7360 -700 {lab=Source[4]}
N 7360 -790 7360 -700 {lab=Source[4]}
N 7280 -700 7280 -650 {lab=Source[4]}
N 7190 -700 7280 -700 {lab=Source[4]}
N 7560 -960 7560 -850 {lab=Sforce}
N 7650 -960 7730 -960 {lab=Sforce}
N 7730 -960 7730 -850 {lab=Sforce}
N 7560 -790 7560 -700 {lab=Source[4]}
N 7650 -700 7730 -700 {lab=Source[4]}
N 7730 -790 7730 -700 {lab=Source[4]}
N 7650 -700 7650 -650 {lab=Source[4]}
N 7560 -700 7650 -700 {lab=Source[4]}
N 7460 -650 7650 -650 {lab=Source[4]}
N 7650 -1140 9150 -1140 {lab=Sforce}
N 7650 -1140 7650 -960 {lab=Sforce}
N 7560 -960 7650 -960 {lab=Sforce}
N 7280 -1170 8780 -1170 {lab=Ssense}
N 7280 -1170 7280 -960 {lab=Ssense}
N 7190 -960 7280 -960 {lab=Ssense}
N 6780 -1200 8280 -1200 {lab=Gdrive}
N 6780 -1200 6780 -960 {lab=Gdrive}
N 6690 -960 6780 -960 {lab=Gdrive}
N 7000 -1230 8500 -1230 {lab=Vcl}
N 7000 -1230 7000 -850 {lab=Vcl}
N 7240 -1380 7240 -1350 {lab=ctrl_p[4]}
N 7110 -1350 7240 -1350 {lab=ctrl_p[4]}
N 6610 -1350 6610 -820 {lab=ctrl_p[4]}
N 6610 -820 6650 -820 {lab=ctrl_p[4]}
N 7110 -820 7150 -820 {lab=ctrl_p[4]}
N 7110 -1350 7110 -820 {lab=ctrl_p[4]}
N 6610 -1350 7110 -1350 {lab=ctrl_p[4]}
N 6940 -1320 6940 -820 {lab=ctrl_n[4]}
N 6900 -820 6940 -820 {lab=ctrl_n[4]}
N 6940 -1320 7290 -1320 {lab=ctrl_n[4]}
N 7290 -1380 7290 -1320 {lab=ctrl_n[4]}
N 7400 -820 7440 -820 {lab=ctrl_n[4]}
N 7480 -820 7520 -820 {lab=ctrl_p[4]}
N 7440 -1320 7800 -1320 {lab=ctrl_n[4]}
N 7440 -1320 7440 -820 {lab=ctrl_n[4]}
N 7290 -1320 7440 -1320 {lab=ctrl_n[4]}
N 7240 -1350 7480 -1350 {lab=ctrl_p[4]}
N 7480 -1350 7480 -820 {lab=ctrl_p[4]}
N 7800 -1320 7800 -820 {lab=ctrl_n[4]}
N 7770 -820 7800 -820 {lab=ctrl_n[4]}
N 7460 -650 7460 -580 {lab=Source[4]}
N 7280 -650 7460 -650 {lab=Source[4]}
N 6690 -820 6730 -820 {lab=#net29}
N 6730 -820 6730 -460 {lab=#net29}
N 7000 -820 7040 -820 {lab=#net30}
N 7040 -820 7040 -460 {lab=#net30}
N 6730 -400 6730 -330 {lab=Vss}
N 7600 -330 7900 -330 {lab=Vss}
N 7900 -1080 7900 -330 {lab=Vss}
N 7900 -1080 9400 -1080 {lab=Vss}
N 7870 -1110 9370 -1110 {lab=1.2V}
N 7870 -1110 7870 -360 {lab=1.2V}
N 7040 -400 7040 -330 {lab=Vss}
N 6730 -330 7040 -330 {lab=Vss}
N 7690 -360 7870 -360 {lab=1.2V}
N 7320 -820 7360 -820 {lab=#net31}
N 7320 -820 7320 -460 {lab=#net31}
N 7190 -820 7230 -820 {lab=#net32}
N 7230 -820 7230 -460 {lab=#net32}
N 7320 -400 7320 -360 {lab=1.2V}
N 7230 -400 7230 -330 {lab=Vss}
N 7040 -330 7230 -330 {lab=Vss}
N 6810 -820 6860 -820 {lab=#net33}
N 6810 -820 6810 -460 {lab=#net33}
N 6810 -400 6810 -360 {lab=1.2V}
N 6810 -360 7320 -360 {lab=1.2V}
N 7560 -820 7600 -820 {lab=#net34}
N 7600 -820 7600 -460 {lab=#net34}
N 7690 -820 7730 -820 {lab=#net35}
N 7690 -820 7690 -460 {lab=#net35}
N 7690 -400 7690 -360 {lab=1.2V}
N 7320 -360 7690 -360 {lab=1.2V}
N 7600 -400 7600 -330 {lab=Vss}
N 7230 -330 7600 -330 {lab=Vss}
N 8190 -960 8190 -850 {lab=Gdrive}
N 8280 -960 8360 -960 {lab=Gdrive}
N 8360 -960 8360 -850 {lab=Gdrive}
N 8190 -790 8190 -700 {lab=Gate[5]}
N 8280 -700 8360 -700 {lab=Gate[5]}
N 8360 -790 8360 -700 {lab=Gate[5]}
N 8500 -790 8500 -650 {lab=Gate[5]}
N 8390 -650 8500 -650 {lab=Gate[5]}
N 8280 -700 8280 -650 {lab=Gate[5]}
N 8190 -700 8280 -700 {lab=Gate[5]}
N 8390 -650 8390 -570 {lab=Gate[5]}
N 8280 -650 8390 -650 {lab=Gate[5]}
N 8440 -820 8460 -820 {lab=ctrl_n[5]}
N 8690 -960 8690 -850 {lab=Ssense}
N 8780 -960 8860 -960 {lab=Ssense}
N 8860 -960 8860 -850 {lab=Ssense}
N 8690 -790 8690 -700 {lab=Source[5]}
N 8780 -700 8860 -700 {lab=Source[5]}
N 8860 -790 8860 -700 {lab=Source[5]}
N 8780 -700 8780 -650 {lab=Source[5]}
N 8690 -700 8780 -700 {lab=Source[5]}
N 9060 -960 9060 -850 {lab=Sforce}
N 9150 -960 9230 -960 {lab=Sforce}
N 9230 -960 9230 -850 {lab=Sforce}
N 9060 -790 9060 -700 {lab=Source[5]}
N 9150 -700 9230 -700 {lab=Source[5]}
N 9230 -790 9230 -700 {lab=Source[5]}
N 9150 -700 9150 -650 {lab=Source[5]}
N 9060 -700 9150 -700 {lab=Source[5]}
N 8960 -650 9150 -650 {lab=Source[5]}
N 9150 -1140 10650 -1140 {lab=Sforce}
N 9150 -1140 9150 -960 {lab=Sforce}
N 9060 -960 9150 -960 {lab=Sforce}
N 8780 -1170 10280 -1170 {lab=Ssense}
N 8780 -1170 8780 -960 {lab=Ssense}
N 8690 -960 8780 -960 {lab=Ssense}
N 8280 -1200 9780 -1200 {lab=Gdrive}
N 8280 -1200 8280 -960 {lab=Gdrive}
N 8190 -960 8280 -960 {lab=Gdrive}
N 8500 -1230 10000 -1230 {lab=Vcl}
N 8500 -1230 8500 -850 {lab=Vcl}
N 8740 -1380 8740 -1350 {lab=ctrl_p[5]}
N 8610 -1350 8740 -1350 {lab=ctrl_p[5]}
N 8110 -1350 8110 -820 {lab=ctrl_p[5]}
N 8110 -820 8150 -820 {lab=ctrl_p[5]}
N 8610 -820 8650 -820 {lab=ctrl_p[5]}
N 8610 -1350 8610 -820 {lab=ctrl_p[5]}
N 8110 -1350 8610 -1350 {lab=ctrl_p[5]}
N 8440 -1320 8440 -820 {lab=ctrl_n[5]}
N 8400 -820 8440 -820 {lab=ctrl_n[5]}
N 8440 -1320 8790 -1320 {lab=ctrl_n[5]}
N 8790 -1380 8790 -1320 {lab=ctrl_n[5]}
N 8900 -820 8940 -820 {lab=ctrl_n[5]}
N 8980 -820 9020 -820 {lab=ctrl_p[5]}
N 8940 -1320 9300 -1320 {lab=ctrl_n[5]}
N 8940 -1320 8940 -820 {lab=ctrl_n[5]}
N 8790 -1320 8940 -1320 {lab=ctrl_n[5]}
N 8740 -1350 8980 -1350 {lab=ctrl_p[5]}
N 8980 -1350 8980 -820 {lab=ctrl_p[5]}
N 9300 -1320 9300 -820 {lab=ctrl_n[5]}
N 9270 -820 9300 -820 {lab=ctrl_n[5]}
N 8960 -650 8960 -580 {lab=Source[5]}
N 8780 -650 8960 -650 {lab=Source[5]}
N 8190 -820 8230 -820 {lab=#net36}
N 8230 -820 8230 -460 {lab=#net36}
N 8500 -820 8540 -820 {lab=#net37}
N 8540 -820 8540 -460 {lab=#net37}
N 8230 -400 8230 -330 {lab=Vss}
N 9100 -330 9400 -330 {lab=Vss}
N 9400 -1080 9400 -330 {lab=Vss}
N 9400 -1080 10900 -1080 {lab=Vss}
N 9370 -1110 10870 -1110 {lab=1.2V}
N 9370 -1110 9370 -360 {lab=1.2V}
N 8540 -400 8540 -330 {lab=Vss}
N 8230 -330 8540 -330 {lab=Vss}
N 9190 -360 9370 -360 {lab=1.2V}
N 8820 -820 8860 -820 {lab=#net38}
N 8820 -820 8820 -460 {lab=#net38}
N 8690 -820 8730 -820 {lab=#net39}
N 8730 -820 8730 -460 {lab=#net39}
N 8820 -400 8820 -360 {lab=1.2V}
N 8730 -400 8730 -330 {lab=Vss}
N 8540 -330 8730 -330 {lab=Vss}
N 8310 -820 8360 -820 {lab=#net40}
N 8310 -820 8310 -460 {lab=#net40}
N 8310 -400 8310 -360 {lab=1.2V}
N 8310 -360 8820 -360 {lab=1.2V}
N 9060 -820 9100 -820 {lab=#net41}
N 9100 -820 9100 -460 {lab=#net41}
N 9190 -820 9230 -820 {lab=#net42}
N 9190 -820 9190 -460 {lab=#net42}
N 9190 -400 9190 -360 {lab=1.2V}
N 8820 -360 9190 -360 {lab=1.2V}
N 9100 -400 9100 -330 {lab=Vss}
N 8730 -330 9100 -330 {lab=Vss}
N 9690 -960 9690 -850 {lab=Gdrive}
N 9780 -960 9860 -960 {lab=Gdrive}
N 9860 -960 9860 -850 {lab=Gdrive}
N 9690 -790 9690 -700 {lab=Gate[6]}
N 9780 -700 9860 -700 {lab=Gate[6]}
N 9860 -790 9860 -700 {lab=Gate[6]}
N 10000 -790 10000 -650 {lab=Gate[6]}
N 9890 -650 10000 -650 {lab=Gate[6]}
N 9780 -700 9780 -650 {lab=Gate[6]}
N 9690 -700 9780 -700 {lab=Gate[6]}
N 9890 -650 9890 -570 {lab=Gate[6]}
N 9780 -650 9890 -650 {lab=Gate[6]}
N 9940 -820 9960 -820 {lab=ctrl_n[6]}
N 10190 -960 10190 -850 {lab=Ssense}
N 10280 -960 10360 -960 {lab=Ssense}
N 10360 -960 10360 -850 {lab=Ssense}
N 10190 -790 10190 -700 {lab=Source[6]}
N 10280 -700 10360 -700 {lab=Source[6]}
N 10360 -790 10360 -700 {lab=Source[6]}
N 10280 -700 10280 -650 {lab=Source[6]}
N 10190 -700 10280 -700 {lab=Source[6]}
N 10560 -960 10560 -850 {lab=Sforce}
N 10650 -960 10730 -960 {lab=Sforce}
N 10730 -960 10730 -850 {lab=Sforce}
N 10560 -790 10560 -700 {lab=Source[6]}
N 10650 -700 10730 -700 {lab=Source[6]}
N 10730 -790 10730 -700 {lab=Source[6]}
N 10650 -700 10650 -650 {lab=Source[6]}
N 10560 -700 10650 -700 {lab=Source[6]}
N 10460 -650 10650 -650 {lab=Source[6]}
N 10650 -1140 12150 -1140 {lab=Sforce}
N 10650 -1140 10650 -960 {lab=Sforce}
N 10560 -960 10650 -960 {lab=Sforce}
N 10280 -1170 11780 -1170 {lab=Ssense}
N 10280 -1170 10280 -960 {lab=Ssense}
N 10190 -960 10280 -960 {lab=Ssense}
N 9780 -1200 11280 -1200 {lab=Gdrive}
N 9780 -1200 9780 -960 {lab=Gdrive}
N 9690 -960 9780 -960 {lab=Gdrive}
N 10000 -1230 11500 -1230 {lab=Vcl}
N 10000 -1230 10000 -850 {lab=Vcl}
N 10240 -1380 10240 -1350 {lab=ctrl_p[6]}
N 10110 -1350 10240 -1350 {lab=ctrl_p[6]}
N 9610 -1350 9610 -820 {lab=ctrl_p[6]}
N 9610 -820 9650 -820 {lab=ctrl_p[6]}
N 10110 -820 10150 -820 {lab=ctrl_p[6]}
N 10110 -1350 10110 -820 {lab=ctrl_p[6]}
N 9610 -1350 10110 -1350 {lab=ctrl_p[6]}
N 9940 -1320 9940 -820 {lab=ctrl_n[6]}
N 9900 -820 9940 -820 {lab=ctrl_n[6]}
N 9940 -1320 10290 -1320 {lab=ctrl_n[6]}
N 10290 -1380 10290 -1320 {lab=ctrl_n[6]}
N 10400 -820 10440 -820 {lab=ctrl_n[6]}
N 10480 -820 10520 -820 {lab=ctrl_p[6]}
N 10440 -1320 10800 -1320 {lab=ctrl_n[6]}
N 10440 -1320 10440 -820 {lab=ctrl_n[6]}
N 10290 -1320 10440 -1320 {lab=ctrl_n[6]}
N 10240 -1350 10480 -1350 {lab=ctrl_p[6]}
N 10480 -1350 10480 -820 {lab=ctrl_p[6]}
N 10800 -1320 10800 -820 {lab=ctrl_n[6]}
N 10770 -820 10800 -820 {lab=ctrl_n[6]}
N 10460 -650 10460 -580 {lab=Source[6]}
N 10280 -650 10460 -650 {lab=Source[6]}
N 9690 -820 9730 -820 {lab=#net43}
N 9730 -820 9730 -460 {lab=#net43}
N 10000 -820 10040 -820 {lab=#net44}
N 10040 -820 10040 -460 {lab=#net44}
N 9730 -400 9730 -330 {lab=Vss}
N 10600 -330 10900 -330 {lab=Vss}
N 10900 -1080 10900 -330 {lab=Vss}
N 10900 -1080 12400 -1080 {lab=Vss}
N 10870 -1110 12370 -1110 {lab=1.2V}
N 10870 -1110 10870 -360 {lab=1.2V}
N 10040 -400 10040 -330 {lab=Vss}
N 9730 -330 10040 -330 {lab=Vss}
N 10690 -360 10870 -360 {lab=1.2V}
N 10320 -820 10360 -820 {lab=#net45}
N 10320 -820 10320 -460 {lab=#net45}
N 10190 -820 10230 -820 {lab=#net46}
N 10230 -820 10230 -460 {lab=#net46}
N 10320 -400 10320 -360 {lab=1.2V}
N 10230 -400 10230 -330 {lab=Vss}
N 10040 -330 10230 -330 {lab=Vss}
N 9810 -820 9860 -820 {lab=#net47}
N 9810 -820 9810 -460 {lab=#net47}
N 9810 -400 9810 -360 {lab=1.2V}
N 9810 -360 10320 -360 {lab=1.2V}
N 10560 -820 10600 -820 {lab=#net48}
N 10600 -820 10600 -460 {lab=#net48}
N 10690 -820 10730 -820 {lab=#net49}
N 10690 -820 10690 -460 {lab=#net49}
N 10690 -400 10690 -360 {lab=1.2V}
N 10320 -360 10690 -360 {lab=1.2V}
N 10600 -400 10600 -330 {lab=Vss}
N 10230 -330 10600 -330 {lab=Vss}
N 11190 -960 11190 -850 {lab=Gdrive}
N 11280 -960 11360 -960 {lab=Gdrive}
N 11360 -960 11360 -850 {lab=Gdrive}
N 11190 -790 11190 -700 {lab=Gate[7]}
N 11280 -700 11360 -700 {lab=Gate[7]}
N 11360 -790 11360 -700 {lab=Gate[7]}
N 11500 -790 11500 -650 {lab=Gate[7]}
N 11390 -650 11500 -650 {lab=Gate[7]}
N 11280 -700 11280 -650 {lab=Gate[7]}
N 11190 -700 11280 -700 {lab=Gate[7]}
N 11390 -650 11390 -570 {lab=Gate[7]}
N 11280 -650 11390 -650 {lab=Gate[7]}
N 11440 -820 11460 -820 {lab=ctrl_n[7]}
N 11690 -960 11690 -850 {lab=Ssense}
N 11780 -960 11860 -960 {lab=Ssense}
N 11860 -960 11860 -850 {lab=Ssense}
N 11690 -790 11690 -700 {lab=Source[7]}
N 11780 -700 11860 -700 {lab=Source[7]}
N 11860 -790 11860 -700 {lab=Source[7]}
N 11780 -700 11780 -650 {lab=Source[7]}
N 11690 -700 11780 -700 {lab=Source[7]}
N 12060 -960 12060 -850 {lab=Sforce}
N 12150 -960 12230 -960 {lab=Sforce}
N 12230 -960 12230 -850 {lab=Sforce}
N 12060 -790 12060 -700 {lab=Source[7]}
N 12150 -700 12230 -700 {lab=Source[7]}
N 12230 -790 12230 -700 {lab=Source[7]}
N 12150 -700 12150 -650 {lab=Source[7]}
N 12060 -700 12150 -700 {lab=Source[7]}
N 11960 -650 12150 -650 {lab=Source[7]}
N 12150 -1140 13650 -1140 {lab=Sforce}
N 12150 -1140 12150 -960 {lab=Sforce}
N 12060 -960 12150 -960 {lab=Sforce}
N 11780 -1170 13280 -1170 {lab=Ssense}
N 11780 -1170 11780 -960 {lab=Ssense}
N 11690 -960 11780 -960 {lab=Ssense}
N 11280 -1200 12780 -1200 {lab=Gdrive}
N 11280 -1200 11280 -960 {lab=Gdrive}
N 11190 -960 11280 -960 {lab=Gdrive}
N 11500 -1230 13000 -1230 {lab=Vcl}
N 11500 -1230 11500 -850 {lab=Vcl}
N 11740 -1380 11740 -1350 {lab=ctrl_p[7]}
N 11610 -1350 11740 -1350 {lab=ctrl_p[7]}
N 11110 -1350 11110 -820 {lab=ctrl_p[7]}
N 11110 -820 11150 -820 {lab=ctrl_p[7]}
N 11610 -820 11650 -820 {lab=ctrl_p[7]}
N 11610 -1350 11610 -820 {lab=ctrl_p[7]}
N 11110 -1350 11610 -1350 {lab=ctrl_p[7]}
N 11440 -1320 11440 -820 {lab=ctrl_n[7]}
N 11400 -820 11440 -820 {lab=ctrl_n[7]}
N 11440 -1320 11790 -1320 {lab=ctrl_n[7]}
N 11790 -1380 11790 -1320 {lab=ctrl_n[7]}
N 11900 -820 11940 -820 {lab=ctrl_n[7]}
N 11980 -820 12020 -820 {lab=ctrl_p[7]}
N 11940 -1320 12300 -1320 {lab=ctrl_n[7]}
N 11940 -1320 11940 -820 {lab=ctrl_n[7]}
N 11790 -1320 11940 -1320 {lab=ctrl_n[7]}
N 11740 -1350 11980 -1350 {lab=ctrl_p[7]}
N 11980 -1350 11980 -820 {lab=ctrl_p[7]}
N 12300 -1320 12300 -820 {lab=ctrl_n[7]}
N 12270 -820 12300 -820 {lab=ctrl_n[7]}
N 11960 -650 11960 -580 {lab=Source[7]}
N 11780 -650 11960 -650 {lab=Source[7]}
N 11190 -820 11230 -820 {lab=#net50}
N 11230 -820 11230 -460 {lab=#net50}
N 11500 -820 11540 -820 {lab=#net51}
N 11540 -820 11540 -460 {lab=#net51}
N 11230 -400 11230 -330 {lab=Vss}
N 12100 -330 12400 -330 {lab=Vss}
N 12400 -1080 12400 -330 {lab=Vss}
N 12400 -1080 13900 -1080 {lab=Vss}
N 12370 -1110 13870 -1110 {lab=1.2V}
N 12370 -1110 12370 -360 {lab=1.2V}
N 11540 -400 11540 -330 {lab=Vss}
N 11230 -330 11540 -330 {lab=Vss}
N 12190 -360 12370 -360 {lab=1.2V}
N 11820 -820 11860 -820 {lab=#net52}
N 11820 -820 11820 -460 {lab=#net52}
N 11690 -820 11730 -820 {lab=#net53}
N 11730 -820 11730 -460 {lab=#net53}
N 11820 -400 11820 -360 {lab=1.2V}
N 11730 -400 11730 -330 {lab=Vss}
N 11540 -330 11730 -330 {lab=Vss}
N 11310 -820 11360 -820 {lab=#net54}
N 11310 -820 11310 -460 {lab=#net54}
N 11310 -400 11310 -360 {lab=1.2V}
N 11310 -360 11820 -360 {lab=1.2V}
N 12060 -820 12100 -820 {lab=#net55}
N 12100 -820 12100 -460 {lab=#net55}
N 12190 -820 12230 -820 {lab=#net56}
N 12190 -820 12190 -460 {lab=#net56}
N 12190 -400 12190 -360 {lab=1.2V}
N 11820 -360 12190 -360 {lab=1.2V}
N 12100 -400 12100 -330 {lab=Vss}
N 11730 -330 12100 -330 {lab=Vss}
N 12690 -960 12690 -850 {lab=Gdrive}
N 12780 -960 12860 -960 {lab=Gdrive}
N 12860 -960 12860 -850 {lab=Gdrive}
N 12690 -790 12690 -700 {lab=Gate[8]}
N 12780 -700 12860 -700 {lab=Gate[8]}
N 12860 -790 12860 -700 {lab=Gate[8]}
N 13000 -790 13000 -650 {lab=Gate[8]}
N 12890 -650 13000 -650 {lab=Gate[8]}
N 12780 -700 12780 -650 {lab=Gate[8]}
N 12690 -700 12780 -700 {lab=Gate[8]}
N 12890 -650 12890 -570 {lab=Gate[8]}
N 12780 -650 12890 -650 {lab=Gate[8]}
N 12940 -820 12960 -820 {lab=ctrl_n[8]}
N 13190 -960 13190 -850 {lab=Ssense}
N 13280 -960 13360 -960 {lab=Ssense}
N 13360 -960 13360 -850 {lab=Ssense}
N 13190 -790 13190 -700 {lab=Source[8]}
N 13280 -700 13360 -700 {lab=Source[8]}
N 13360 -790 13360 -700 {lab=Source[8]}
N 13280 -700 13280 -650 {lab=Source[8]}
N 13190 -700 13280 -700 {lab=Source[8]}
N 13560 -960 13560 -850 {lab=Sforce}
N 13650 -960 13730 -960 {lab=Sforce}
N 13730 -960 13730 -850 {lab=Sforce}
N 13560 -790 13560 -700 {lab=Source[8]}
N 13650 -700 13730 -700 {lab=Source[8]}
N 13730 -790 13730 -700 {lab=Source[8]}
N 13650 -700 13650 -650 {lab=Source[8]}
N 13560 -700 13650 -700 {lab=Source[8]}
N 13460 -650 13650 -650 {lab=Source[8]}
N 13650 -1140 15150 -1140 {lab=Sforce}
N 13650 -1140 13650 -960 {lab=Sforce}
N 13560 -960 13650 -960 {lab=Sforce}
N 13280 -1170 14780 -1170 {lab=Ssense}
N 13280 -1170 13280 -960 {lab=Ssense}
N 13190 -960 13280 -960 {lab=Ssense}
N 12780 -1200 14280 -1200 {lab=Gdrive}
N 12780 -1200 12780 -960 {lab=Gdrive}
N 12690 -960 12780 -960 {lab=Gdrive}
N 13000 -1230 14500 -1230 {lab=Vcl}
N 13000 -1230 13000 -850 {lab=Vcl}
N 13240 -1380 13240 -1350 {lab=ctrl_p[8]}
N 13110 -1350 13240 -1350 {lab=ctrl_p[8]}
N 12610 -1350 12610 -820 {lab=ctrl_p[8]}
N 12610 -820 12650 -820 {lab=ctrl_p[8]}
N 13110 -820 13150 -820 {lab=ctrl_p[8]}
N 13110 -1350 13110 -820 {lab=ctrl_p[8]}
N 12610 -1350 13110 -1350 {lab=ctrl_p[8]}
N 12940 -1320 12940 -820 {lab=ctrl_n[8]}
N 12900 -820 12940 -820 {lab=ctrl_n[8]}
N 12940 -1320 13290 -1320 {lab=ctrl_n[8]}
N 13290 -1380 13290 -1320 {lab=ctrl_n[8]}
N 13400 -820 13440 -820 {lab=ctrl_n[8]}
N 13480 -820 13520 -820 {lab=ctrl_p[8]}
N 13440 -1320 13800 -1320 {lab=ctrl_n[8]}
N 13440 -1320 13440 -820 {lab=ctrl_n[8]}
N 13290 -1320 13440 -1320 {lab=ctrl_n[8]}
N 13240 -1350 13480 -1350 {lab=ctrl_p[8]}
N 13480 -1350 13480 -820 {lab=ctrl_p[8]}
N 13800 -1320 13800 -820 {lab=ctrl_n[8]}
N 13770 -820 13800 -820 {lab=ctrl_n[8]}
N 13460 -650 13460 -580 {lab=Source[8]}
N 13280 -650 13460 -650 {lab=Source[8]}
N 12690 -820 12730 -820 {lab=#net57}
N 12730 -820 12730 -460 {lab=#net57}
N 13000 -820 13040 -820 {lab=#net58}
N 13040 -820 13040 -460 {lab=#net58}
N 12730 -400 12730 -330 {lab=Vss}
N 13600 -330 13900 -330 {lab=Vss}
N 13900 -1080 13900 -330 {lab=Vss}
N 13900 -1080 15400 -1080 {lab=Vss}
N 13870 -1110 15370 -1110 {lab=1.2V}
N 13870 -1110 13870 -360 {lab=1.2V}
N 13040 -400 13040 -330 {lab=Vss}
N 12730 -330 13040 -330 {lab=Vss}
N 13690 -360 13870 -360 {lab=1.2V}
N 13320 -820 13360 -820 {lab=#net59}
N 13320 -820 13320 -460 {lab=#net59}
N 13190 -820 13230 -820 {lab=#net60}
N 13230 -820 13230 -460 {lab=#net60}
N 13320 -400 13320 -360 {lab=1.2V}
N 13230 -400 13230 -330 {lab=Vss}
N 13040 -330 13230 -330 {lab=Vss}
N 12810 -820 12860 -820 {lab=#net61}
N 12810 -820 12810 -460 {lab=#net61}
N 12810 -400 12810 -360 {lab=1.2V}
N 12810 -360 13320 -360 {lab=1.2V}
N 13560 -820 13600 -820 {lab=#net62}
N 13600 -820 13600 -460 {lab=#net62}
N 13690 -820 13730 -820 {lab=#net63}
N 13690 -820 13690 -460 {lab=#net63}
N 13690 -400 13690 -360 {lab=1.2V}
N 13320 -360 13690 -360 {lab=1.2V}
N 13600 -400 13600 -330 {lab=Vss}
N 13230 -330 13600 -330 {lab=Vss}
N 14190 -960 14190 -850 {lab=Gdrive}
N 14280 -960 14360 -960 {lab=Gdrive}
N 14360 -960 14360 -850 {lab=Gdrive}
N 14190 -790 14190 -700 {lab=Gate[9]}
N 14280 -700 14360 -700 {lab=Gate[9]}
N 14360 -790 14360 -700 {lab=Gate[9]}
N 14500 -790 14500 -650 {lab=Gate[9]}
N 14390 -650 14500 -650 {lab=Gate[9]}
N 14280 -700 14280 -650 {lab=Gate[9]}
N 14190 -700 14280 -700 {lab=Gate[9]}
N 14390 -650 14390 -570 {lab=Gate[9]}
N 14280 -650 14390 -650 {lab=Gate[9]}
N 14440 -820 14460 -820 {lab=ctrl_n[9]}
N 14690 -960 14690 -850 {lab=Ssense}
N 14780 -960 14860 -960 {lab=Ssense}
N 14860 -960 14860 -850 {lab=Ssense}
N 14690 -790 14690 -700 {lab=Source[9]}
N 14780 -700 14860 -700 {lab=Source[9]}
N 14860 -790 14860 -700 {lab=Source[9]}
N 14780 -700 14780 -650 {lab=Source[9]}
N 14690 -700 14780 -700 {lab=Source[9]}
N 15060 -960 15060 -850 {lab=Sforce}
N 15150 -960 15230 -960 {lab=Sforce}
N 15230 -960 15230 -850 {lab=Sforce}
N 15060 -790 15060 -700 {lab=Source[9]}
N 15150 -700 15230 -700 {lab=Source[9]}
N 15230 -790 15230 -700 {lab=Source[9]}
N 15150 -700 15150 -650 {lab=Source[9]}
N 15060 -700 15150 -700 {lab=Source[9]}
N 14960 -650 15150 -650 {lab=Source[9]}
N 15150 -1140 16650 -1140 {lab=Sforce}
N 15150 -1140 15150 -960 {lab=Sforce}
N 15060 -960 15150 -960 {lab=Sforce}
N 14780 -1170 16280 -1170 {lab=Ssense}
N 14780 -1170 14780 -960 {lab=Ssense}
N 14690 -960 14780 -960 {lab=Ssense}
N 14280 -1200 15780 -1200 {lab=Gdrive}
N 14280 -1200 14280 -960 {lab=Gdrive}
N 14190 -960 14280 -960 {lab=Gdrive}
N 14500 -1230 16000 -1230 {lab=Vcl}
N 14500 -1230 14500 -850 {lab=Vcl}
N 14740 -1380 14740 -1350 {lab=ctrl_p[9]}
N 14610 -1350 14740 -1350 {lab=ctrl_p[9]}
N 14110 -1350 14110 -820 {lab=ctrl_p[9]}
N 14110 -820 14150 -820 {lab=ctrl_p[9]}
N 14610 -820 14650 -820 {lab=ctrl_p[9]}
N 14610 -1350 14610 -820 {lab=ctrl_p[9]}
N 14110 -1350 14610 -1350 {lab=ctrl_p[9]}
N 14440 -1320 14440 -820 {lab=ctrl_n[9]}
N 14400 -820 14440 -820 {lab=ctrl_n[9]}
N 14440 -1320 14790 -1320 {lab=ctrl_n[9]}
N 14790 -1380 14790 -1320 {lab=ctrl_n[9]}
N 14900 -820 14940 -820 {lab=ctrl_n[9]}
N 14980 -820 15020 -820 {lab=ctrl_p[9]}
N 14940 -1320 15300 -1320 {lab=ctrl_n[9]}
N 14940 -1320 14940 -820 {lab=ctrl_n[9]}
N 14790 -1320 14940 -1320 {lab=ctrl_n[9]}
N 14740 -1350 14980 -1350 {lab=ctrl_p[9]}
N 14980 -1350 14980 -820 {lab=ctrl_p[9]}
N 15300 -1320 15300 -820 {lab=ctrl_n[9]}
N 15270 -820 15300 -820 {lab=ctrl_n[9]}
N 14960 -650 14960 -580 {lab=Source[9]}
N 14780 -650 14960 -650 {lab=Source[9]}
N 14190 -820 14230 -820 {lab=#net64}
N 14230 -820 14230 -460 {lab=#net64}
N 14500 -820 14540 -820 {lab=#net65}
N 14540 -820 14540 -460 {lab=#net65}
N 14230 -400 14230 -330 {lab=Vss}
N 15100 -330 15400 -330 {lab=Vss}
N 15400 -1080 15400 -330 {lab=Vss}
N 15400 -1080 16900 -1080 {lab=Vss}
N 15370 -1110 16870 -1110 {lab=1.2V}
N 15370 -1110 15370 -360 {lab=1.2V}
N 14540 -400 14540 -330 {lab=Vss}
N 14230 -330 14540 -330 {lab=Vss}
N 15190 -360 15370 -360 {lab=1.2V}
N 14820 -820 14860 -820 {lab=#net66}
N 14820 -820 14820 -460 {lab=#net66}
N 14690 -820 14730 -820 {lab=#net67}
N 14730 -820 14730 -460 {lab=#net67}
N 14820 -400 14820 -360 {lab=1.2V}
N 14730 -400 14730 -330 {lab=Vss}
N 14540 -330 14730 -330 {lab=Vss}
N 14310 -820 14360 -820 {lab=#net68}
N 14310 -820 14310 -460 {lab=#net68}
N 14310 -400 14310 -360 {lab=1.2V}
N 14310 -360 14820 -360 {lab=1.2V}
N 15060 -820 15100 -820 {lab=#net69}
N 15100 -820 15100 -460 {lab=#net69}
N 15190 -820 15230 -820 {lab=#net70}
N 15190 -820 15190 -460 {lab=#net70}
N 15190 -400 15190 -360 {lab=1.2V}
N 14820 -360 15190 -360 {lab=1.2V}
N 15100 -400 15100 -330 {lab=Vss}
N 14730 -330 15100 -330 {lab=Vss}
N 15690 -960 15690 -850 {lab=Gdrive}
N 15780 -960 15860 -960 {lab=Gdrive}
N 15860 -960 15860 -850 {lab=Gdrive}
N 15690 -790 15690 -700 {lab=Gate[10]}
N 15780 -700 15860 -700 {lab=Gate[10]}
N 15860 -790 15860 -700 {lab=Gate[10]}
N 16000 -790 16000 -650 {lab=Gate[10]}
N 15890 -650 16000 -650 {lab=Gate[10]}
N 15780 -700 15780 -650 {lab=Gate[10]}
N 15690 -700 15780 -700 {lab=Gate[10]}
N 15890 -650 15890 -570 {lab=Gate[10]}
N 15780 -650 15890 -650 {lab=Gate[10]}
N 15940 -820 15960 -820 {lab=ctrl_n[10]}
N 16190 -960 16190 -850 {lab=Ssense}
N 16280 -960 16360 -960 {lab=Ssense}
N 16360 -960 16360 -850 {lab=Ssense}
N 16190 -790 16190 -700 {lab=Source[10]}
N 16280 -700 16360 -700 {lab=Source[10]}
N 16360 -790 16360 -700 {lab=Source[10]}
N 16280 -700 16280 -650 {lab=Source[10]}
N 16190 -700 16280 -700 {lab=Source[10]}
N 16560 -960 16560 -850 {lab=Sforce}
N 16650 -960 16730 -960 {lab=Sforce}
N 16730 -960 16730 -850 {lab=Sforce}
N 16560 -790 16560 -700 {lab=Source[10]}
N 16650 -700 16730 -700 {lab=Source[10]}
N 16730 -790 16730 -700 {lab=Source[10]}
N 16650 -700 16650 -650 {lab=Source[10]}
N 16560 -700 16650 -700 {lab=Source[10]}
N 16460 -650 16650 -650 {lab=Source[10]}
N 16650 -1140 18150 -1140 {lab=Sforce}
N 16650 -1140 16650 -960 {lab=Sforce}
N 16560 -960 16650 -960 {lab=Sforce}
N 16280 -1170 17780 -1170 {lab=Ssense}
N 16280 -1170 16280 -960 {lab=Ssense}
N 16190 -960 16280 -960 {lab=Ssense}
N 15780 -1200 17280 -1200 {lab=Gdrive}
N 15780 -1200 15780 -960 {lab=Gdrive}
N 15690 -960 15780 -960 {lab=Gdrive}
N 16000 -1230 17500 -1230 {lab=Vcl}
N 16000 -1230 16000 -850 {lab=Vcl}
N 16240 -1380 16240 -1350 {lab=ctrl_p[10]}
N 16110 -1350 16240 -1350 {lab=ctrl_p[10]}
N 15610 -1350 15610 -820 {lab=ctrl_p[10]}
N 15610 -820 15650 -820 {lab=ctrl_p[10]}
N 16110 -820 16150 -820 {lab=ctrl_p[10]}
N 16110 -1350 16110 -820 {lab=ctrl_p[10]}
N 15610 -1350 16110 -1350 {lab=ctrl_p[10]}
N 15940 -1320 15940 -820 {lab=ctrl_n[10]}
N 15900 -820 15940 -820 {lab=ctrl_n[10]}
N 15940 -1320 16290 -1320 {lab=ctrl_n[10]}
N 16290 -1380 16290 -1320 {lab=ctrl_n[10]}
N 16400 -820 16440 -820 {lab=ctrl_n[10]}
N 16480 -820 16520 -820 {lab=ctrl_p[10]}
N 16440 -1320 16800 -1320 {lab=ctrl_n[10]}
N 16440 -1320 16440 -820 {lab=ctrl_n[10]}
N 16290 -1320 16440 -1320 {lab=ctrl_n[10]}
N 16240 -1350 16480 -1350 {lab=ctrl_p[10]}
N 16480 -1350 16480 -820 {lab=ctrl_p[10]}
N 16800 -1320 16800 -820 {lab=ctrl_n[10]}
N 16770 -820 16800 -820 {lab=ctrl_n[10]}
N 16460 -650 16460 -580 {lab=Source[10]}
N 16280 -650 16460 -650 {lab=Source[10]}
N 15690 -820 15730 -820 {lab=#net71}
N 15730 -820 15730 -460 {lab=#net71}
N 16000 -820 16040 -820 {lab=#net72}
N 16040 -820 16040 -460 {lab=#net72}
N 15730 -400 15730 -330 {lab=Vss}
N 16600 -330 16900 -330 {lab=Vss}
N 16900 -1080 16900 -330 {lab=Vss}
N 16900 -1080 18400 -1080 {lab=Vss}
N 16870 -1110 18370 -1110 {lab=1.2V}
N 16870 -1110 16870 -360 {lab=1.2V}
N 16040 -400 16040 -330 {lab=Vss}
N 15730 -330 16040 -330 {lab=Vss}
N 16690 -360 16870 -360 {lab=1.2V}
N 16320 -820 16360 -820 {lab=#net73}
N 16320 -820 16320 -460 {lab=#net73}
N 16190 -820 16230 -820 {lab=#net74}
N 16230 -820 16230 -460 {lab=#net74}
N 16320 -400 16320 -360 {lab=1.2V}
N 16230 -400 16230 -330 {lab=Vss}
N 16040 -330 16230 -330 {lab=Vss}
N 15810 -820 15860 -820 {lab=#net75}
N 15810 -820 15810 -460 {lab=#net75}
N 15810 -400 15810 -360 {lab=1.2V}
N 15810 -360 16320 -360 {lab=1.2V}
N 16560 -820 16600 -820 {lab=#net76}
N 16600 -820 16600 -460 {lab=#net76}
N 16690 -820 16730 -820 {lab=#net77}
N 16690 -820 16690 -460 {lab=#net77}
N 16690 -400 16690 -360 {lab=1.2V}
N 16320 -360 16690 -360 {lab=1.2V}
N 16600 -400 16600 -330 {lab=Vss}
N 16230 -330 16600 -330 {lab=Vss}
N 17190 -960 17190 -850 {lab=Gdrive}
N 17280 -960 17360 -960 {lab=Gdrive}
N 17360 -960 17360 -850 {lab=Gdrive}
N 17190 -790 17190 -700 {lab=Gate[11]}
N 17280 -700 17360 -700 {lab=Gate[11]}
N 17360 -790 17360 -700 {lab=Gate[11]}
N 17500 -790 17500 -650 {lab=Gate[11]}
N 17390 -650 17500 -650 {lab=Gate[11]}
N 17280 -700 17280 -650 {lab=Gate[11]}
N 17190 -700 17280 -700 {lab=Gate[11]}
N 17390 -650 17390 -570 {lab=Gate[11]}
N 17280 -650 17390 -650 {lab=Gate[11]}
N 17440 -820 17460 -820 {lab=ctrl_n[11]}
N 17690 -960 17690 -850 {lab=Ssense}
N 17780 -960 17860 -960 {lab=Ssense}
N 17860 -960 17860 -850 {lab=Ssense}
N 17690 -790 17690 -700 {lab=Source[11]}
N 17780 -700 17860 -700 {lab=Source[11]}
N 17860 -790 17860 -700 {lab=Source[11]}
N 17780 -700 17780 -650 {lab=Source[11]}
N 17690 -700 17780 -700 {lab=Source[11]}
N 18060 -960 18060 -850 {lab=Sforce}
N 18150 -960 18230 -960 {lab=Sforce}
N 18230 -960 18230 -850 {lab=Sforce}
N 18060 -790 18060 -700 {lab=Source[11]}
N 18150 -700 18230 -700 {lab=Source[11]}
N 18230 -790 18230 -700 {lab=Source[11]}
N 18150 -700 18150 -650 {lab=Source[11]}
N 18060 -700 18150 -700 {lab=Source[11]}
N 17960 -650 18150 -650 {lab=Source[11]}
N 18150 -1140 19650 -1140 {lab=Sforce}
N 18150 -1140 18150 -960 {lab=Sforce}
N 18060 -960 18150 -960 {lab=Sforce}
N 17780 -1170 19280 -1170 {lab=Ssense}
N 17780 -1170 17780 -960 {lab=Ssense}
N 17690 -960 17780 -960 {lab=Ssense}
N 17280 -1200 18780 -1200 {lab=Gdrive}
N 17280 -1200 17280 -960 {lab=Gdrive}
N 17190 -960 17280 -960 {lab=Gdrive}
N 17500 -1230 19000 -1230 {lab=Vcl}
N 17500 -1230 17500 -850 {lab=Vcl}
N 17740 -1380 17740 -1350 {lab=ctrl_p[11]}
N 17610 -1350 17740 -1350 {lab=ctrl_p[11]}
N 17110 -1350 17110 -820 {lab=ctrl_p[11]}
N 17110 -820 17150 -820 {lab=ctrl_p[11]}
N 17610 -820 17650 -820 {lab=ctrl_p[11]}
N 17610 -1350 17610 -820 {lab=ctrl_p[11]}
N 17110 -1350 17610 -1350 {lab=ctrl_p[11]}
N 17440 -1320 17440 -820 {lab=ctrl_n[11]}
N 17400 -820 17440 -820 {lab=ctrl_n[11]}
N 17440 -1320 17790 -1320 {lab=ctrl_n[11]}
N 17790 -1380 17790 -1320 {lab=ctrl_n[11]}
N 17900 -820 17940 -820 {lab=ctrl_n[11]}
N 17980 -820 18020 -820 {lab=ctrl_p[11]}
N 17940 -1320 18300 -1320 {lab=ctrl_n[11]}
N 17940 -1320 17940 -820 {lab=ctrl_n[11]}
N 17790 -1320 17940 -1320 {lab=ctrl_n[11]}
N 17740 -1350 17980 -1350 {lab=ctrl_p[11]}
N 17980 -1350 17980 -820 {lab=ctrl_p[11]}
N 18300 -1320 18300 -820 {lab=ctrl_n[11]}
N 18270 -820 18300 -820 {lab=ctrl_n[11]}
N 17960 -650 17960 -580 {lab=Source[11]}
N 17780 -650 17960 -650 {lab=Source[11]}
N 17190 -820 17230 -820 {lab=#net78}
N 17230 -820 17230 -460 {lab=#net78}
N 17500 -820 17540 -820 {lab=#net79}
N 17540 -820 17540 -460 {lab=#net79}
N 17230 -400 17230 -330 {lab=Vss}
N 18100 -330 18400 -330 {lab=Vss}
N 18400 -1080 18400 -330 {lab=Vss}
N 18400 -1080 19900 -1080 {lab=Vss}
N 18370 -1110 19870 -1110 {lab=1.2V}
N 18370 -1110 18370 -360 {lab=1.2V}
N 17540 -400 17540 -330 {lab=Vss}
N 17230 -330 17540 -330 {lab=Vss}
N 18190 -360 18370 -360 {lab=1.2V}
N 17820 -820 17860 -820 {lab=#net80}
N 17820 -820 17820 -460 {lab=#net80}
N 17690 -820 17730 -820 {lab=#net81}
N 17730 -820 17730 -460 {lab=#net81}
N 17820 -400 17820 -360 {lab=1.2V}
N 17730 -400 17730 -330 {lab=Vss}
N 17540 -330 17730 -330 {lab=Vss}
N 17310 -820 17360 -820 {lab=#net82}
N 17310 -820 17310 -460 {lab=#net82}
N 17310 -400 17310 -360 {lab=1.2V}
N 17310 -360 17820 -360 {lab=1.2V}
N 18060 -820 18100 -820 {lab=#net83}
N 18100 -820 18100 -460 {lab=#net83}
N 18190 -820 18230 -820 {lab=#net84}
N 18190 -820 18190 -460 {lab=#net84}
N 18190 -400 18190 -360 {lab=1.2V}
N 17820 -360 18190 -360 {lab=1.2V}
N 18100 -400 18100 -330 {lab=Vss}
N 17730 -330 18100 -330 {lab=Vss}
N 18690 -960 18690 -850 {lab=Gdrive}
N 18780 -960 18860 -960 {lab=Gdrive}
N 18860 -960 18860 -850 {lab=Gdrive}
N 18690 -790 18690 -700 {lab=Gate[12]}
N 18780 -700 18860 -700 {lab=Gate[12]}
N 18860 -790 18860 -700 {lab=Gate[12]}
N 19000 -790 19000 -650 {lab=Gate[12]}
N 18890 -650 19000 -650 {lab=Gate[12]}
N 18780 -700 18780 -650 {lab=Gate[12]}
N 18690 -700 18780 -700 {lab=Gate[12]}
N 18890 -650 18890 -570 {lab=Gate[12]}
N 18780 -650 18890 -650 {lab=Gate[12]}
N 18940 -820 18960 -820 {lab=ctrl_n[12]}
N 19190 -960 19190 -850 {lab=Ssense}
N 19280 -960 19360 -960 {lab=Ssense}
N 19360 -960 19360 -850 {lab=Ssense}
N 19190 -790 19190 -700 {lab=Source[12]}
N 19280 -700 19360 -700 {lab=Source[12]}
N 19360 -790 19360 -700 {lab=Source[12]}
N 19280 -700 19280 -650 {lab=Source[12]}
N 19190 -700 19280 -700 {lab=Source[12]}
N 19560 -960 19560 -850 {lab=Sforce}
N 19650 -960 19730 -960 {lab=Sforce}
N 19730 -960 19730 -850 {lab=Sforce}
N 19560 -790 19560 -700 {lab=Source[12]}
N 19650 -700 19730 -700 {lab=Source[12]}
N 19730 -790 19730 -700 {lab=Source[12]}
N 19650 -700 19650 -650 {lab=Source[12]}
N 19560 -700 19650 -700 {lab=Source[12]}
N 19460 -650 19650 -650 {lab=Source[12]}
N 19650 -1140 21150 -1140 {lab=Sforce}
N 19650 -1140 19650 -960 {lab=Sforce}
N 19560 -960 19650 -960 {lab=Sforce}
N 19280 -1170 20780 -1170 {lab=Ssense}
N 19280 -1170 19280 -960 {lab=Ssense}
N 19190 -960 19280 -960 {lab=Ssense}
N 18780 -1200 20280 -1200 {lab=Gdrive}
N 18780 -1200 18780 -960 {lab=Gdrive}
N 18690 -960 18780 -960 {lab=Gdrive}
N 19000 -1230 20500 -1230 {lab=Vcl}
N 19000 -1230 19000 -850 {lab=Vcl}
N 19240 -1380 19240 -1350 {lab=ctrl_p[12]}
N 19110 -1350 19240 -1350 {lab=ctrl_p[12]}
N 18610 -1350 18610 -820 {lab=ctrl_p[12]}
N 18610 -820 18650 -820 {lab=ctrl_p[12]}
N 19110 -820 19150 -820 {lab=ctrl_p[12]}
N 19110 -1350 19110 -820 {lab=ctrl_p[12]}
N 18610 -1350 19110 -1350 {lab=ctrl_p[12]}
N 18940 -1320 18940 -820 {lab=ctrl_n[12]}
N 18900 -820 18940 -820 {lab=ctrl_n[12]}
N 18940 -1320 19290 -1320 {lab=ctrl_n[12]}
N 19290 -1380 19290 -1320 {lab=ctrl_n[12]}
N 19400 -820 19440 -820 {lab=ctrl_n[12]}
N 19480 -820 19520 -820 {lab=ctrl_p[12]}
N 19440 -1320 19800 -1320 {lab=ctrl_n[12]}
N 19440 -1320 19440 -820 {lab=ctrl_n[12]}
N 19290 -1320 19440 -1320 {lab=ctrl_n[12]}
N 19240 -1350 19480 -1350 {lab=ctrl_p[12]}
N 19480 -1350 19480 -820 {lab=ctrl_p[12]}
N 19800 -1320 19800 -820 {lab=ctrl_n[12]}
N 19770 -820 19800 -820 {lab=ctrl_n[12]}
N 19460 -650 19460 -580 {lab=Source[12]}
N 19280 -650 19460 -650 {lab=Source[12]}
N 18690 -820 18730 -820 {lab=#net85}
N 18730 -820 18730 -460 {lab=#net85}
N 19000 -820 19040 -820 {lab=#net86}
N 19040 -820 19040 -460 {lab=#net86}
N 18730 -400 18730 -330 {lab=Vss}
N 19600 -330 19900 -330 {lab=Vss}
N 19900 -1080 19900 -330 {lab=Vss}
N 19900 -1080 21400 -1080 {lab=Vss}
N 19870 -1110 21370 -1110 {lab=1.2V}
N 19870 -1110 19870 -360 {lab=1.2V}
N 19040 -400 19040 -330 {lab=Vss}
N 18730 -330 19040 -330 {lab=Vss}
N 19690 -360 19870 -360 {lab=1.2V}
N 19320 -820 19360 -820 {lab=#net87}
N 19320 -820 19320 -460 {lab=#net87}
N 19190 -820 19230 -820 {lab=#net88}
N 19230 -820 19230 -460 {lab=#net88}
N 19320 -400 19320 -360 {lab=1.2V}
N 19230 -400 19230 -330 {lab=Vss}
N 19040 -330 19230 -330 {lab=Vss}
N 18810 -820 18860 -820 {lab=#net89}
N 18810 -820 18810 -460 {lab=#net89}
N 18810 -400 18810 -360 {lab=1.2V}
N 18810 -360 19320 -360 {lab=1.2V}
N 19560 -820 19600 -820 {lab=#net90}
N 19600 -820 19600 -460 {lab=#net90}
N 19690 -820 19730 -820 {lab=#net91}
N 19690 -820 19690 -460 {lab=#net91}
N 19690 -400 19690 -360 {lab=1.2V}
N 19320 -360 19690 -360 {lab=1.2V}
N 19600 -400 19600 -330 {lab=Vss}
N 19230 -330 19600 -330 {lab=Vss}
N 20190 -960 20190 -850 {lab=Gdrive}
N 20280 -960 20360 -960 {lab=Gdrive}
N 20360 -960 20360 -850 {lab=Gdrive}
N 20190 -790 20190 -700 {lab=Gate[13]}
N 20280 -700 20360 -700 {lab=Gate[13]}
N 20360 -790 20360 -700 {lab=Gate[13]}
N 20500 -790 20500 -650 {lab=Gate[13]}
N 20390 -650 20500 -650 {lab=Gate[13]}
N 20280 -700 20280 -650 {lab=Gate[13]}
N 20190 -700 20280 -700 {lab=Gate[13]}
N 20390 -650 20390 -570 {lab=Gate[13]}
N 20280 -650 20390 -650 {lab=Gate[13]}
N 20440 -820 20460 -820 {lab=ctrl_n[13]}
N 20690 -960 20690 -850 {lab=Ssense}
N 20780 -960 20860 -960 {lab=Ssense}
N 20860 -960 20860 -850 {lab=Ssense}
N 20690 -790 20690 -700 {lab=Source[13]}
N 20780 -700 20860 -700 {lab=Source[13]}
N 20860 -790 20860 -700 {lab=Source[13]}
N 20780 -700 20780 -650 {lab=Source[13]}
N 20690 -700 20780 -700 {lab=Source[13]}
N 21060 -960 21060 -850 {lab=Sforce}
N 21150 -960 21230 -960 {lab=Sforce}
N 21230 -960 21230 -850 {lab=Sforce}
N 21060 -790 21060 -700 {lab=Source[13]}
N 21150 -700 21230 -700 {lab=Source[13]}
N 21230 -790 21230 -700 {lab=Source[13]}
N 21150 -700 21150 -650 {lab=Source[13]}
N 21060 -700 21150 -700 {lab=Source[13]}
N 20960 -650 21150 -650 {lab=Source[13]}
N 21150 -1140 22650 -1140 {lab=Sforce}
N 21150 -1140 21150 -960 {lab=Sforce}
N 21060 -960 21150 -960 {lab=Sforce}
N 20780 -1170 22280 -1170 {lab=Ssense}
N 20780 -1170 20780 -960 {lab=Ssense}
N 20690 -960 20780 -960 {lab=Ssense}
N 20280 -1200 21780 -1200 {lab=Gdrive}
N 20280 -1200 20280 -960 {lab=Gdrive}
N 20190 -960 20280 -960 {lab=Gdrive}
N 20500 -1230 22000 -1230 {lab=Vcl}
N 20500 -1230 20500 -850 {lab=Vcl}
N 20740 -1380 20740 -1350 {lab=ctrl_p[13]}
N 20610 -1350 20740 -1350 {lab=ctrl_p[13]}
N 20110 -1350 20110 -820 {lab=ctrl_p[13]}
N 20110 -820 20150 -820 {lab=ctrl_p[13]}
N 20610 -820 20650 -820 {lab=ctrl_p[13]}
N 20610 -1350 20610 -820 {lab=ctrl_p[13]}
N 20110 -1350 20610 -1350 {lab=ctrl_p[13]}
N 20440 -1320 20440 -820 {lab=ctrl_n[13]}
N 20400 -820 20440 -820 {lab=ctrl_n[13]}
N 20440 -1320 20790 -1320 {lab=ctrl_n[13]}
N 20790 -1380 20790 -1320 {lab=ctrl_n[13]}
N 20900 -820 20940 -820 {lab=ctrl_n[13]}
N 20980 -820 21020 -820 {lab=ctrl_p[13]}
N 20940 -1320 21300 -1320 {lab=ctrl_n[13]}
N 20940 -1320 20940 -820 {lab=ctrl_n[13]}
N 20790 -1320 20940 -1320 {lab=ctrl_n[13]}
N 20740 -1350 20980 -1350 {lab=ctrl_p[13]}
N 20980 -1350 20980 -820 {lab=ctrl_p[13]}
N 21300 -1320 21300 -820 {lab=ctrl_n[13]}
N 21270 -820 21300 -820 {lab=ctrl_n[13]}
N 20960 -650 20960 -580 {lab=Source[13]}
N 20780 -650 20960 -650 {lab=Source[13]}
N 20190 -820 20230 -820 {lab=#net92}
N 20230 -820 20230 -460 {lab=#net92}
N 20500 -820 20540 -820 {lab=#net93}
N 20540 -820 20540 -460 {lab=#net93}
N 20230 -400 20230 -330 {lab=Vss}
N 21100 -330 21400 -330 {lab=Vss}
N 21400 -1080 21400 -330 {lab=Vss}
N 21400 -1080 22900 -1080 {lab=Vss}
N 21370 -1110 22870 -1110 {lab=1.2V}
N 21370 -1110 21370 -360 {lab=1.2V}
N 20540 -400 20540 -330 {lab=Vss}
N 20230 -330 20540 -330 {lab=Vss}
N 21190 -360 21370 -360 {lab=1.2V}
N 20820 -820 20860 -820 {lab=#net94}
N 20820 -820 20820 -460 {lab=#net94}
N 20690 -820 20730 -820 {lab=#net95}
N 20730 -820 20730 -460 {lab=#net95}
N 20820 -400 20820 -360 {lab=1.2V}
N 20730 -400 20730 -330 {lab=Vss}
N 20540 -330 20730 -330 {lab=Vss}
N 20310 -820 20360 -820 {lab=#net96}
N 20310 -820 20310 -460 {lab=#net96}
N 20310 -400 20310 -360 {lab=1.2V}
N 20310 -360 20820 -360 {lab=1.2V}
N 21060 -820 21100 -820 {lab=#net97}
N 21100 -820 21100 -460 {lab=#net97}
N 21190 -820 21230 -820 {lab=#net98}
N 21190 -820 21190 -460 {lab=#net98}
N 21190 -400 21190 -360 {lab=1.2V}
N 20820 -360 21190 -360 {lab=1.2V}
N 21100 -400 21100 -330 {lab=Vss}
N 20730 -330 21100 -330 {lab=Vss}
N 21690 -960 21690 -850 {lab=Gdrive}
N 21780 -960 21860 -960 {lab=Gdrive}
N 21860 -960 21860 -850 {lab=Gdrive}
N 21690 -790 21690 -700 {lab=Gate[14]}
N 21780 -700 21860 -700 {lab=Gate[14]}
N 21860 -790 21860 -700 {lab=Gate[14]}
N 22000 -790 22000 -650 {lab=Gate[14]}
N 21890 -650 22000 -650 {lab=Gate[14]}
N 21780 -700 21780 -650 {lab=Gate[14]}
N 21690 -700 21780 -700 {lab=Gate[14]}
N 21890 -650 21890 -570 {lab=Gate[14]}
N 21780 -650 21890 -650 {lab=Gate[14]}
N 21940 -820 21960 -820 {lab=ctrl_n[14]}
N 22190 -960 22190 -850 {lab=Ssense}
N 22280 -960 22360 -960 {lab=Ssense}
N 22360 -960 22360 -850 {lab=Ssense}
N 22190 -790 22190 -700 {lab=Source[14]}
N 22280 -700 22360 -700 {lab=Source[14]}
N 22360 -790 22360 -700 {lab=Source[14]}
N 22280 -700 22280 -650 {lab=Source[14]}
N 22190 -700 22280 -700 {lab=Source[14]}
N 22560 -960 22560 -850 {lab=Sforce}
N 22650 -960 22730 -960 {lab=Sforce}
N 22730 -960 22730 -850 {lab=Sforce}
N 22560 -790 22560 -700 {lab=Source[14]}
N 22650 -700 22730 -700 {lab=Source[14]}
N 22730 -790 22730 -700 {lab=Source[14]}
N 22650 -700 22650 -650 {lab=Source[14]}
N 22560 -700 22650 -700 {lab=Source[14]}
N 22460 -650 22650 -650 {lab=Source[14]}
N 22650 -1140 24150 -1140 {lab=Sforce}
N 22650 -1140 22650 -960 {lab=Sforce}
N 22560 -960 22650 -960 {lab=Sforce}
N 22280 -1170 23780 -1170 {lab=Ssense}
N 22280 -1170 22280 -960 {lab=Ssense}
N 22190 -960 22280 -960 {lab=Ssense}
N 21780 -1200 23280 -1200 {lab=Gdrive}
N 21780 -1200 21780 -960 {lab=Gdrive}
N 21690 -960 21780 -960 {lab=Gdrive}
N 22000 -1230 23500 -1230 {lab=Vcl}
N 22000 -1230 22000 -850 {lab=Vcl}
N 22240 -1380 22240 -1350 {lab=ctrl_p[14]}
N 22110 -1350 22240 -1350 {lab=ctrl_p[14]}
N 21610 -1350 21610 -820 {lab=ctrl_p[14]}
N 21610 -820 21650 -820 {lab=ctrl_p[14]}
N 22110 -820 22150 -820 {lab=ctrl_p[14]}
N 22110 -1350 22110 -820 {lab=ctrl_p[14]}
N 21610 -1350 22110 -1350 {lab=ctrl_p[14]}
N 21940 -1320 21940 -820 {lab=ctrl_n[14]}
N 21900 -820 21940 -820 {lab=ctrl_n[14]}
N 21940 -1320 22290 -1320 {lab=ctrl_n[14]}
N 22290 -1380 22290 -1320 {lab=ctrl_n[14]}
N 22400 -820 22440 -820 {lab=ctrl_n[14]}
N 22480 -820 22520 -820 {lab=ctrl_p[14]}
N 22440 -1320 22800 -1320 {lab=ctrl_n[14]}
N 22440 -1320 22440 -820 {lab=ctrl_n[14]}
N 22290 -1320 22440 -1320 {lab=ctrl_n[14]}
N 22240 -1350 22480 -1350 {lab=ctrl_p[14]}
N 22480 -1350 22480 -820 {lab=ctrl_p[14]}
N 22800 -1320 22800 -820 {lab=ctrl_n[14]}
N 22770 -820 22800 -820 {lab=ctrl_n[14]}
N 22460 -650 22460 -580 {lab=Source[14]}
N 22280 -650 22460 -650 {lab=Source[14]}
N 21690 -820 21730 -820 {lab=#net99}
N 21730 -820 21730 -460 {lab=#net99}
N 22000 -820 22040 -820 {lab=#net100}
N 22040 -820 22040 -460 {lab=#net100}
N 21730 -400 21730 -330 {lab=Vss}
N 22600 -330 22900 -330 {lab=Vss}
N 22900 -1080 22900 -330 {lab=Vss}
N 22900 -1080 24400 -1080 {lab=Vss}
N 22870 -1110 24370 -1110 {lab=1.2V}
N 22870 -1110 22870 -360 {lab=1.2V}
N 22040 -400 22040 -330 {lab=Vss}
N 21730 -330 22040 -330 {lab=Vss}
N 22690 -360 22870 -360 {lab=1.2V}
N 22320 -820 22360 -820 {lab=#net101}
N 22320 -820 22320 -460 {lab=#net101}
N 22190 -820 22230 -820 {lab=#net102}
N 22230 -820 22230 -460 {lab=#net102}
N 22320 -400 22320 -360 {lab=1.2V}
N 22230 -400 22230 -330 {lab=Vss}
N 22040 -330 22230 -330 {lab=Vss}
N 21810 -820 21860 -820 {lab=#net103}
N 21810 -820 21810 -460 {lab=#net103}
N 21810 -400 21810 -360 {lab=1.2V}
N 21810 -360 22320 -360 {lab=1.2V}
N 22560 -820 22600 -820 {lab=#net104}
N 22600 -820 22600 -460 {lab=#net104}
N 22690 -820 22730 -820 {lab=#net105}
N 22690 -820 22690 -460 {lab=#net105}
N 22690 -400 22690 -360 {lab=1.2V}
N 22320 -360 22690 -360 {lab=1.2V}
N 22600 -400 22600 -330 {lab=Vss}
N 22230 -330 22600 -330 {lab=Vss}
N 23190 -960 23190 -850 {lab=Gdrive}
N 23280 -960 23360 -960 {lab=Gdrive}
N 23360 -960 23360 -850 {lab=Gdrive}
N 23190 -790 23190 -700 {lab=Gate[15]}
N 23280 -700 23360 -700 {lab=Gate[15]}
N 23360 -790 23360 -700 {lab=Gate[15]}
N 23500 -790 23500 -650 {lab=Gate[15]}
N 23390 -650 23500 -650 {lab=Gate[15]}
N 23280 -700 23280 -650 {lab=Gate[15]}
N 23190 -700 23280 -700 {lab=Gate[15]}
N 23390 -650 23390 -570 {lab=Gate[15]}
N 23280 -650 23390 -650 {lab=Gate[15]}
N 23440 -820 23460 -820 {lab=ctrl_n[15]}
N 23690 -960 23690 -850 {lab=Ssense}
N 23780 -960 23860 -960 {lab=Ssense}
N 23860 -960 23860 -850 {lab=Ssense}
N 23690 -790 23690 -700 {lab=Source[15]}
N 23780 -700 23860 -700 {lab=Source[15]}
N 23860 -790 23860 -700 {lab=Source[15]}
N 23780 -700 23780 -650 {lab=Source[15]}
N 23690 -700 23780 -700 {lab=Source[15]}
N 24060 -960 24060 -850 {lab=Sforce}
N 24150 -960 24230 -960 {lab=Sforce}
N 24230 -960 24230 -850 {lab=Sforce}
N 24060 -790 24060 -700 {lab=Source[15]}
N 24150 -700 24230 -700 {lab=Source[15]}
N 24230 -790 24230 -700 {lab=Source[15]}
N 24150 -700 24150 -650 {lab=Source[15]}
N 24060 -700 24150 -700 {lab=Source[15]}
N 23960 -650 24150 -650 {lab=Source[15]}
N 24150 -1140 25650 -1140 {lab=Sforce}
N 24150 -1140 24150 -960 {lab=Sforce}
N 24060 -960 24150 -960 {lab=Sforce}
N 23780 -1170 25280 -1170 {lab=Ssense}
N 23780 -1170 23780 -960 {lab=Ssense}
N 23690 -960 23780 -960 {lab=Ssense}
N 23280 -1200 24780 -1200 {lab=Gdrive}
N 23280 -1200 23280 -960 {lab=Gdrive}
N 23190 -960 23280 -960 {lab=Gdrive}
N 23500 -1230 25000 -1230 {lab=Vcl}
N 23500 -1230 23500 -850 {lab=Vcl}
N 23740 -1380 23740 -1350 {lab=ctrl_p[15]}
N 23610 -1350 23740 -1350 {lab=ctrl_p[15]}
N 23110 -1350 23110 -820 {lab=ctrl_p[15]}
N 23110 -820 23150 -820 {lab=ctrl_p[15]}
N 23610 -820 23650 -820 {lab=ctrl_p[15]}
N 23610 -1350 23610 -820 {lab=ctrl_p[15]}
N 23110 -1350 23610 -1350 {lab=ctrl_p[15]}
N 23440 -1320 23440 -820 {lab=ctrl_n[15]}
N 23400 -820 23440 -820 {lab=ctrl_n[15]}
N 23440 -1320 23790 -1320 {lab=ctrl_n[15]}
N 23790 -1380 23790 -1320 {lab=ctrl_n[15]}
N 23900 -820 23940 -820 {lab=ctrl_n[15]}
N 23980 -820 24020 -820 {lab=ctrl_p[15]}
N 23940 -1320 24300 -1320 {lab=ctrl_n[15]}
N 23940 -1320 23940 -820 {lab=ctrl_n[15]}
N 23790 -1320 23940 -1320 {lab=ctrl_n[15]}
N 23740 -1350 23980 -1350 {lab=ctrl_p[15]}
N 23980 -1350 23980 -820 {lab=ctrl_p[15]}
N 24300 -1320 24300 -820 {lab=ctrl_n[15]}
N 24270 -820 24300 -820 {lab=ctrl_n[15]}
N 23960 -650 23960 -580 {lab=Source[15]}
N 23780 -650 23960 -650 {lab=Source[15]}
N 23190 -820 23230 -820 {lab=#net106}
N 23230 -820 23230 -460 {lab=#net106}
N 23500 -820 23540 -820 {lab=#net107}
N 23540 -820 23540 -460 {lab=#net107}
N 23230 -400 23230 -330 {lab=Vss}
N 24100 -330 24400 -330 {lab=Vss}
N 24400 -1080 24400 -330 {lab=Vss}
N 24400 -1080 25900 -1080 {lab=Vss}
N 24370 -1110 25870 -1110 {lab=1.2V}
N 24370 -1110 24370 -360 {lab=1.2V}
N 23540 -400 23540 -330 {lab=Vss}
N 23230 -330 23540 -330 {lab=Vss}
N 24190 -360 24370 -360 {lab=1.2V}
N 23820 -820 23860 -820 {lab=#net108}
N 23820 -820 23820 -460 {lab=#net108}
N 23690 -820 23730 -820 {lab=#net109}
N 23730 -820 23730 -460 {lab=#net109}
N 23820 -400 23820 -360 {lab=1.2V}
N 23730 -400 23730 -330 {lab=Vss}
N 23540 -330 23730 -330 {lab=Vss}
N 23310 -820 23360 -820 {lab=#net110}
N 23310 -820 23310 -460 {lab=#net110}
N 23310 -400 23310 -360 {lab=1.2V}
N 23310 -360 23820 -360 {lab=1.2V}
N 24060 -820 24100 -820 {lab=#net111}
N 24100 -820 24100 -460 {lab=#net111}
N 24190 -820 24230 -820 {lab=#net112}
N 24190 -820 24190 -460 {lab=#net112}
N 24190 -400 24190 -360 {lab=1.2V}
N 23820 -360 24190 -360 {lab=1.2V}
N 24100 -400 24100 -330 {lab=Vss}
N 23730 -330 24100 -330 {lab=Vss}
N 24690 -960 24690 -850 {lab=Gdrive}
N 24780 -960 24860 -960 {lab=Gdrive}
N 24860 -960 24860 -850 {lab=Gdrive}
N 24690 -790 24690 -700 {lab=Gate[16]}
N 24780 -700 24860 -700 {lab=Gate[16]}
N 24860 -790 24860 -700 {lab=Gate[16]}
N 25000 -790 25000 -650 {lab=Gate[16]}
N 24890 -650 25000 -650 {lab=Gate[16]}
N 24780 -700 24780 -650 {lab=Gate[16]}
N 24690 -700 24780 -700 {lab=Gate[16]}
N 24890 -650 24890 -570 {lab=Gate[16]}
N 24780 -650 24890 -650 {lab=Gate[16]}
N 24940 -820 24960 -820 {lab=ctrl_n[16]}
N 25190 -960 25190 -850 {lab=Ssense}
N 25280 -960 25360 -960 {lab=Ssense}
N 25360 -960 25360 -850 {lab=Ssense}
N 25190 -790 25190 -700 {lab=Source[16]}
N 25280 -700 25360 -700 {lab=Source[16]}
N 25360 -790 25360 -700 {lab=Source[16]}
N 25280 -700 25280 -650 {lab=Source[16]}
N 25190 -700 25280 -700 {lab=Source[16]}
N 25560 -960 25560 -850 {lab=Sforce}
N 25650 -960 25730 -960 {lab=Sforce}
N 25730 -960 25730 -850 {lab=Sforce}
N 25560 -790 25560 -700 {lab=Source[16]}
N 25650 -700 25730 -700 {lab=Source[16]}
N 25730 -790 25730 -700 {lab=Source[16]}
N 25650 -700 25650 -650 {lab=Source[16]}
N 25560 -700 25650 -700 {lab=Source[16]}
N 25460 -650 25650 -650 {lab=Source[16]}
N 25650 -1140 27150 -1140 {lab=Sforce}
N 25650 -1140 25650 -960 {lab=Sforce}
N 25560 -960 25650 -960 {lab=Sforce}
N 25280 -1170 26780 -1170 {lab=Ssense}
N 25280 -1170 25280 -960 {lab=Ssense}
N 25190 -960 25280 -960 {lab=Ssense}
N 24780 -1200 26280 -1200 {lab=Gdrive}
N 24780 -1200 24780 -960 {lab=Gdrive}
N 24690 -960 24780 -960 {lab=Gdrive}
N 25000 -1230 26500 -1230 {lab=Vcl}
N 25000 -1230 25000 -850 {lab=Vcl}
N 25240 -1380 25240 -1350 {lab=ctrl_p[16]}
N 25110 -1350 25240 -1350 {lab=ctrl_p[16]}
N 24610 -1350 24610 -820 {lab=ctrl_p[16]}
N 24610 -820 24650 -820 {lab=ctrl_p[16]}
N 25110 -820 25150 -820 {lab=ctrl_p[16]}
N 25110 -1350 25110 -820 {lab=ctrl_p[16]}
N 24610 -1350 25110 -1350 {lab=ctrl_p[16]}
N 24940 -1320 24940 -820 {lab=ctrl_n[16]}
N 24900 -820 24940 -820 {lab=ctrl_n[16]}
N 24940 -1320 25290 -1320 {lab=ctrl_n[16]}
N 25290 -1380 25290 -1320 {lab=ctrl_n[16]}
N 25400 -820 25440 -820 {lab=ctrl_n[16]}
N 25480 -820 25520 -820 {lab=ctrl_p[16]}
N 25440 -1320 25800 -1320 {lab=ctrl_n[16]}
N 25440 -1320 25440 -820 {lab=ctrl_n[16]}
N 25290 -1320 25440 -1320 {lab=ctrl_n[16]}
N 25240 -1350 25480 -1350 {lab=ctrl_p[16]}
N 25480 -1350 25480 -820 {lab=ctrl_p[16]}
N 25800 -1320 25800 -820 {lab=ctrl_n[16]}
N 25770 -820 25800 -820 {lab=ctrl_n[16]}
N 25460 -650 25460 -580 {lab=Source[16]}
N 25280 -650 25460 -650 {lab=Source[16]}
N 24690 -820 24730 -820 {lab=#net113}
N 24730 -820 24730 -460 {lab=#net113}
N 25000 -820 25040 -820 {lab=#net114}
N 25040 -820 25040 -460 {lab=#net114}
N 24730 -400 24730 -330 {lab=Vss}
N 25600 -330 25900 -330 {lab=Vss}
N 25900 -1080 25900 -330 {lab=Vss}
N 25900 -1080 27400 -1080 {lab=Vss}
N 25870 -1110 27370 -1110 {lab=1.2V}
N 25870 -1110 25870 -360 {lab=1.2V}
N 25040 -400 25040 -330 {lab=Vss}
N 24730 -330 25040 -330 {lab=Vss}
N 25690 -360 25870 -360 {lab=1.2V}
N 25320 -820 25360 -820 {lab=#net115}
N 25320 -820 25320 -460 {lab=#net115}
N 25190 -820 25230 -820 {lab=#net116}
N 25230 -820 25230 -460 {lab=#net116}
N 25320 -400 25320 -360 {lab=1.2V}
N 25230 -400 25230 -330 {lab=Vss}
N 25040 -330 25230 -330 {lab=Vss}
N 24810 -820 24860 -820 {lab=#net117}
N 24810 -820 24810 -460 {lab=#net117}
N 24810 -400 24810 -360 {lab=1.2V}
N 24810 -360 25320 -360 {lab=1.2V}
N 25560 -820 25600 -820 {lab=#net118}
N 25600 -820 25600 -460 {lab=#net118}
N 25690 -820 25730 -820 {lab=#net119}
N 25690 -820 25690 -460 {lab=#net119}
N 25690 -400 25690 -360 {lab=1.2V}
N 25320 -360 25690 -360 {lab=1.2V}
N 25600 -400 25600 -330 {lab=Vss}
N 25230 -330 25600 -330 {lab=Vss}
N 26190 -960 26190 -850 {lab=Gdrive}
N 26280 -960 26360 -960 {lab=Gdrive}
N 26360 -960 26360 -850 {lab=Gdrive}
N 26190 -790 26190 -700 {lab=Gate[17]}
N 26280 -700 26360 -700 {lab=Gate[17]}
N 26360 -790 26360 -700 {lab=Gate[17]}
N 26500 -790 26500 -650 {lab=Gate[17]}
N 26390 -650 26500 -650 {lab=Gate[17]}
N 26280 -700 26280 -650 {lab=Gate[17]}
N 26190 -700 26280 -700 {lab=Gate[17]}
N 26390 -650 26390 -570 {lab=Gate[17]}
N 26280 -650 26390 -650 {lab=Gate[17]}
N 26440 -820 26460 -820 {lab=ctrl_n[17]}
N 26690 -960 26690 -850 {lab=Ssense}
N 26780 -960 26860 -960 {lab=Ssense}
N 26860 -960 26860 -850 {lab=Ssense}
N 26690 -790 26690 -700 {lab=Source[17]}
N 26780 -700 26860 -700 {lab=Source[17]}
N 26860 -790 26860 -700 {lab=Source[17]}
N 26780 -700 26780 -650 {lab=Source[17]}
N 26690 -700 26780 -700 {lab=Source[17]}
N 27060 -960 27060 -850 {lab=Sforce}
N 27150 -960 27230 -960 {lab=Sforce}
N 27230 -960 27230 -850 {lab=Sforce}
N 27060 -790 27060 -700 {lab=Source[17]}
N 27150 -700 27230 -700 {lab=Source[17]}
N 27230 -790 27230 -700 {lab=Source[17]}
N 27150 -700 27150 -650 {lab=Source[17]}
N 27060 -700 27150 -700 {lab=Source[17]}
N 26960 -650 27150 -650 {lab=Source[17]}
N 27150 -1140 28650 -1140 {lab=Sforce}
N 27150 -1140 27150 -960 {lab=Sforce}
N 27060 -960 27150 -960 {lab=Sforce}
N 26780 -1170 28280 -1170 {lab=Ssense}
N 26780 -1170 26780 -960 {lab=Ssense}
N 26690 -960 26780 -960 {lab=Ssense}
N 26280 -1200 27780 -1200 {lab=Gdrive}
N 26280 -1200 26280 -960 {lab=Gdrive}
N 26190 -960 26280 -960 {lab=Gdrive}
N 26500 -1230 28000 -1230 {lab=Vcl}
N 26500 -1230 26500 -850 {lab=Vcl}
N 26740 -1380 26740 -1350 {lab=ctrl_p[17]}
N 26610 -1350 26740 -1350 {lab=ctrl_p[17]}
N 26110 -1350 26110 -820 {lab=ctrl_p[17]}
N 26110 -820 26150 -820 {lab=ctrl_p[17]}
N 26610 -820 26650 -820 {lab=ctrl_p[17]}
N 26610 -1350 26610 -820 {lab=ctrl_p[17]}
N 26110 -1350 26610 -1350 {lab=ctrl_p[17]}
N 26440 -1320 26440 -820 {lab=ctrl_n[17]}
N 26400 -820 26440 -820 {lab=ctrl_n[17]}
N 26440 -1320 26790 -1320 {lab=ctrl_n[17]}
N 26790 -1380 26790 -1320 {lab=ctrl_n[17]}
N 26900 -820 26940 -820 {lab=ctrl_n[17]}
N 26980 -820 27020 -820 {lab=ctrl_p[17]}
N 26940 -1320 27300 -1320 {lab=ctrl_n[17]}
N 26940 -1320 26940 -820 {lab=ctrl_n[17]}
N 26790 -1320 26940 -1320 {lab=ctrl_n[17]}
N 26740 -1350 26980 -1350 {lab=ctrl_p[17]}
N 26980 -1350 26980 -820 {lab=ctrl_p[17]}
N 27300 -1320 27300 -820 {lab=ctrl_n[17]}
N 27270 -820 27300 -820 {lab=ctrl_n[17]}
N 26960 -650 26960 -580 {lab=Source[17]}
N 26780 -650 26960 -650 {lab=Source[17]}
N 26190 -820 26230 -820 {lab=#net120}
N 26230 -820 26230 -460 {lab=#net120}
N 26500 -820 26540 -820 {lab=#net121}
N 26540 -820 26540 -460 {lab=#net121}
N 26230 -400 26230 -330 {lab=Vss}
N 27100 -330 27400 -330 {lab=Vss}
N 27400 -1080 27400 -330 {lab=Vss}
N 27400 -1080 28900 -1080 {lab=Vss}
N 27370 -1110 28870 -1110 {lab=1.2V}
N 27370 -1110 27370 -360 {lab=1.2V}
N 26540 -400 26540 -330 {lab=Vss}
N 26230 -330 26540 -330 {lab=Vss}
N 27190 -360 27370 -360 {lab=1.2V}
N 26820 -820 26860 -820 {lab=#net122}
N 26820 -820 26820 -460 {lab=#net122}
N 26690 -820 26730 -820 {lab=#net123}
N 26730 -820 26730 -460 {lab=#net123}
N 26820 -400 26820 -360 {lab=1.2V}
N 26730 -400 26730 -330 {lab=Vss}
N 26540 -330 26730 -330 {lab=Vss}
N 26310 -820 26360 -820 {lab=#net124}
N 26310 -820 26310 -460 {lab=#net124}
N 26310 -400 26310 -360 {lab=1.2V}
N 26310 -360 26820 -360 {lab=1.2V}
N 27060 -820 27100 -820 {lab=#net125}
N 27100 -820 27100 -460 {lab=#net125}
N 27190 -820 27230 -820 {lab=#net126}
N 27190 -820 27190 -460 {lab=#net126}
N 27190 -400 27190 -360 {lab=1.2V}
N 26820 -360 27190 -360 {lab=1.2V}
N 27100 -400 27100 -330 {lab=Vss}
N 26730 -330 27100 -330 {lab=Vss}
N 27690 -960 27690 -850 {lab=Gdrive}
N 27780 -960 27860 -960 {lab=Gdrive}
N 27860 -960 27860 -850 {lab=Gdrive}
N 27690 -790 27690 -700 {lab=Gate[18]}
N 27780 -700 27860 -700 {lab=Gate[18]}
N 27860 -790 27860 -700 {lab=Gate[18]}
N 28000 -790 28000 -650 {lab=Gate[18]}
N 27890 -650 28000 -650 {lab=Gate[18]}
N 27780 -700 27780 -650 {lab=Gate[18]}
N 27690 -700 27780 -700 {lab=Gate[18]}
N 27890 -650 27890 -570 {lab=Gate[18]}
N 27780 -650 27890 -650 {lab=Gate[18]}
N 27940 -820 27960 -820 {lab=ctrl_n[18]}
N 28190 -960 28190 -850 {lab=Ssense}
N 28280 -960 28360 -960 {lab=Ssense}
N 28360 -960 28360 -850 {lab=Ssense}
N 28190 -790 28190 -700 {lab=Source[18]}
N 28280 -700 28360 -700 {lab=Source[18]}
N 28360 -790 28360 -700 {lab=Source[18]}
N 28280 -700 28280 -650 {lab=Source[18]}
N 28190 -700 28280 -700 {lab=Source[18]}
N 28560 -960 28560 -850 {lab=Sforce}
N 28650 -960 28730 -960 {lab=Sforce}
N 28730 -960 28730 -850 {lab=Sforce}
N 28560 -790 28560 -700 {lab=Source[18]}
N 28650 -700 28730 -700 {lab=Source[18]}
N 28730 -790 28730 -700 {lab=Source[18]}
N 28650 -700 28650 -650 {lab=Source[18]}
N 28560 -700 28650 -700 {lab=Source[18]}
N 28460 -650 28650 -650 {lab=Source[18]}
N 28650 -1140 30150 -1140 {lab=Sforce}
N 28650 -1140 28650 -960 {lab=Sforce}
N 28560 -960 28650 -960 {lab=Sforce}
N 28280 -1170 29780 -1170 {lab=Ssense}
N 28280 -1170 28280 -960 {lab=Ssense}
N 28190 -960 28280 -960 {lab=Ssense}
N 27780 -1200 29280 -1200 {lab=Gdrive}
N 27780 -1200 27780 -960 {lab=Gdrive}
N 27690 -960 27780 -960 {lab=Gdrive}
N 28000 -1230 29500 -1230 {lab=Vcl}
N 28000 -1230 28000 -850 {lab=Vcl}
N 28240 -1380 28240 -1350 {lab=ctrl_p[18]}
N 28110 -1350 28240 -1350 {lab=ctrl_p[18]}
N 27610 -1350 27610 -820 {lab=ctrl_p[18]}
N 27610 -820 27650 -820 {lab=ctrl_p[18]}
N 28110 -820 28150 -820 {lab=ctrl_p[18]}
N 28110 -1350 28110 -820 {lab=ctrl_p[18]}
N 27610 -1350 28110 -1350 {lab=ctrl_p[18]}
N 27940 -1320 27940 -820 {lab=ctrl_n[18]}
N 27900 -820 27940 -820 {lab=ctrl_n[18]}
N 27940 -1320 28290 -1320 {lab=ctrl_n[18]}
N 28290 -1380 28290 -1320 {lab=ctrl_n[18]}
N 28400 -820 28440 -820 {lab=ctrl_n[18]}
N 28480 -820 28520 -820 {lab=ctrl_p[18]}
N 28440 -1320 28800 -1320 {lab=ctrl_n[18]}
N 28440 -1320 28440 -820 {lab=ctrl_n[18]}
N 28290 -1320 28440 -1320 {lab=ctrl_n[18]}
N 28240 -1350 28480 -1350 {lab=ctrl_p[18]}
N 28480 -1350 28480 -820 {lab=ctrl_p[18]}
N 28800 -1320 28800 -820 {lab=ctrl_n[18]}
N 28770 -820 28800 -820 {lab=ctrl_n[18]}
N 28460 -650 28460 -580 {lab=Source[18]}
N 28280 -650 28460 -650 {lab=Source[18]}
N 27690 -820 27730 -820 {lab=#net127}
N 27730 -820 27730 -460 {lab=#net127}
N 28000 -820 28040 -820 {lab=#net128}
N 28040 -820 28040 -460 {lab=#net128}
N 27730 -400 27730 -330 {lab=Vss}
N 28600 -330 28900 -330 {lab=Vss}
N 28900 -1080 28900 -330 {lab=Vss}
N 28900 -1080 30400 -1080 {lab=Vss}
N 28870 -1110 30370 -1110 {lab=1.2V}
N 28870 -1110 28870 -360 {lab=1.2V}
N 28040 -400 28040 -330 {lab=Vss}
N 27730 -330 28040 -330 {lab=Vss}
N 28690 -360 28870 -360 {lab=1.2V}
N 28320 -820 28360 -820 {lab=#net129}
N 28320 -820 28320 -460 {lab=#net129}
N 28190 -820 28230 -820 {lab=#net130}
N 28230 -820 28230 -460 {lab=#net130}
N 28320 -400 28320 -360 {lab=1.2V}
N 28230 -400 28230 -330 {lab=Vss}
N 28040 -330 28230 -330 {lab=Vss}
N 27810 -820 27860 -820 {lab=#net131}
N 27810 -820 27810 -460 {lab=#net131}
N 27810 -400 27810 -360 {lab=1.2V}
N 27810 -360 28320 -360 {lab=1.2V}
N 28560 -820 28600 -820 {lab=#net132}
N 28600 -820 28600 -460 {lab=#net132}
N 28690 -820 28730 -820 {lab=#net133}
N 28690 -820 28690 -460 {lab=#net133}
N 28690 -400 28690 -360 {lab=1.2V}
N 28320 -360 28690 -360 {lab=1.2V}
N 28600 -400 28600 -330 {lab=Vss}
N 28230 -330 28600 -330 {lab=Vss}
N 29190 -960 29190 -850 {lab=Gdrive}
N 29280 -960 29360 -960 {lab=Gdrive}
N 29360 -960 29360 -850 {lab=Gdrive}
N 29190 -790 29190 -700 {lab=Gate[19]}
N 29280 -700 29360 -700 {lab=Gate[19]}
N 29360 -790 29360 -700 {lab=Gate[19]}
N 29500 -790 29500 -650 {lab=Gate[19]}
N 29390 -650 29500 -650 {lab=Gate[19]}
N 29280 -700 29280 -650 {lab=Gate[19]}
N 29190 -700 29280 -700 {lab=Gate[19]}
N 29390 -650 29390 -570 {lab=Gate[19]}
N 29280 -650 29390 -650 {lab=Gate[19]}
N 29440 -820 29460 -820 {lab=ctrl_n[19]}
N 29690 -960 29690 -850 {lab=Ssense}
N 29780 -960 29860 -960 {lab=Ssense}
N 29860 -960 29860 -850 {lab=Ssense}
N 29690 -790 29690 -700 {lab=Source[19]}
N 29780 -700 29860 -700 {lab=Source[19]}
N 29860 -790 29860 -700 {lab=Source[19]}
N 29780 -700 29780 -650 {lab=Source[19]}
N 29690 -700 29780 -700 {lab=Source[19]}
N 30060 -960 30060 -850 {lab=Sforce}
N 30150 -960 30230 -960 {lab=Sforce}
N 30230 -960 30230 -850 {lab=Sforce}
N 30060 -790 30060 -700 {lab=Source[19]}
N 30150 -700 30230 -700 {lab=Source[19]}
N 30230 -790 30230 -700 {lab=Source[19]}
N 30150 -700 30150 -650 {lab=Source[19]}
N 30060 -700 30150 -700 {lab=Source[19]}
N 29960 -650 30150 -650 {lab=Source[19]}
N 30150 -1140 31650 -1140 {lab=Sforce}
N 30150 -1140 30150 -960 {lab=Sforce}
N 30060 -960 30150 -960 {lab=Sforce}
N 29780 -1170 31280 -1170 {lab=Ssense}
N 29780 -1170 29780 -960 {lab=Ssense}
N 29690 -960 29780 -960 {lab=Ssense}
N 29280 -1200 30780 -1200 {lab=Gdrive}
N 29280 -1200 29280 -960 {lab=Gdrive}
N 29190 -960 29280 -960 {lab=Gdrive}
N 29500 -1230 31000 -1230 {lab=Vcl}
N 29500 -1230 29500 -850 {lab=Vcl}
N 29740 -1380 29740 -1350 {lab=ctrl_p[19]}
N 29610 -1350 29740 -1350 {lab=ctrl_p[19]}
N 29110 -1350 29110 -820 {lab=ctrl_p[19]}
N 29110 -820 29150 -820 {lab=ctrl_p[19]}
N 29610 -820 29650 -820 {lab=ctrl_p[19]}
N 29610 -1350 29610 -820 {lab=ctrl_p[19]}
N 29110 -1350 29610 -1350 {lab=ctrl_p[19]}
N 29440 -1320 29440 -820 {lab=ctrl_n[19]}
N 29400 -820 29440 -820 {lab=ctrl_n[19]}
N 29440 -1320 29790 -1320 {lab=ctrl_n[19]}
N 29790 -1380 29790 -1320 {lab=ctrl_n[19]}
N 29900 -820 29940 -820 {lab=ctrl_n[19]}
N 29980 -820 30020 -820 {lab=ctrl_p[19]}
N 29940 -1320 30300 -1320 {lab=ctrl_n[19]}
N 29940 -1320 29940 -820 {lab=ctrl_n[19]}
N 29790 -1320 29940 -1320 {lab=ctrl_n[19]}
N 29740 -1350 29980 -1350 {lab=ctrl_p[19]}
N 29980 -1350 29980 -820 {lab=ctrl_p[19]}
N 30300 -1320 30300 -820 {lab=ctrl_n[19]}
N 30270 -820 30300 -820 {lab=ctrl_n[19]}
N 29960 -650 29960 -580 {lab=Source[19]}
N 29780 -650 29960 -650 {lab=Source[19]}
N 29190 -820 29230 -820 {lab=#net134}
N 29230 -820 29230 -460 {lab=#net134}
N 29500 -820 29540 -820 {lab=#net135}
N 29540 -820 29540 -460 {lab=#net135}
N 29230 -400 29230 -330 {lab=Vss}
N 30100 -330 30400 -330 {lab=Vss}
N 30400 -1080 30400 -330 {lab=Vss}
N 30400 -1080 31900 -1080 {lab=Vss}
N 30370 -1110 31870 -1110 {lab=1.2V}
N 30370 -1110 30370 -360 {lab=1.2V}
N 29540 -400 29540 -330 {lab=Vss}
N 29230 -330 29540 -330 {lab=Vss}
N 30190 -360 30370 -360 {lab=1.2V}
N 29820 -820 29860 -820 {lab=#net136}
N 29820 -820 29820 -460 {lab=#net136}
N 29690 -820 29730 -820 {lab=#net137}
N 29730 -820 29730 -460 {lab=#net137}
N 29820 -400 29820 -360 {lab=1.2V}
N 29730 -400 29730 -330 {lab=Vss}
N 29540 -330 29730 -330 {lab=Vss}
N 29310 -820 29360 -820 {lab=#net138}
N 29310 -820 29310 -460 {lab=#net138}
N 29310 -400 29310 -360 {lab=1.2V}
N 29310 -360 29820 -360 {lab=1.2V}
N 30060 -820 30100 -820 {lab=#net139}
N 30100 -820 30100 -460 {lab=#net139}
N 30190 -820 30230 -820 {lab=#net140}
N 30190 -820 30190 -460 {lab=#net140}
N 30190 -400 30190 -360 {lab=1.2V}
N 29820 -360 30190 -360 {lab=1.2V}
N 30100 -400 30100 -330 {lab=Vss}
N 29730 -330 30100 -330 {lab=Vss}
N 30690 -960 30690 -850 {lab=Gdrive}
N 30780 -960 30860 -960 {lab=Gdrive}
N 30860 -960 30860 -850 {lab=Gdrive}
N 30690 -790 30690 -700 {lab=Gate[20]}
N 30780 -700 30860 -700 {lab=Gate[20]}
N 30860 -790 30860 -700 {lab=Gate[20]}
N 31000 -790 31000 -650 {lab=Gate[20]}
N 30890 -650 31000 -650 {lab=Gate[20]}
N 30780 -700 30780 -650 {lab=Gate[20]}
N 30690 -700 30780 -700 {lab=Gate[20]}
N 30890 -650 30890 -570 {lab=Gate[20]}
N 30780 -650 30890 -650 {lab=Gate[20]}
N 30940 -820 30960 -820 {lab=ctrl_n[20]}
N 31190 -960 31190 -850 {lab=Ssense}
N 31280 -960 31360 -960 {lab=Ssense}
N 31360 -960 31360 -850 {lab=Ssense}
N 31190 -790 31190 -700 {lab=Source[20]}
N 31280 -700 31360 -700 {lab=Source[20]}
N 31360 -790 31360 -700 {lab=Source[20]}
N 31280 -700 31280 -650 {lab=Source[20]}
N 31190 -700 31280 -700 {lab=Source[20]}
N 31560 -960 31560 -850 {lab=Sforce}
N 31650 -960 31730 -960 {lab=Sforce}
N 31730 -960 31730 -850 {lab=Sforce}
N 31560 -790 31560 -700 {lab=Source[20]}
N 31650 -700 31730 -700 {lab=Source[20]}
N 31730 -790 31730 -700 {lab=Source[20]}
N 31650 -700 31650 -650 {lab=Source[20]}
N 31560 -700 31650 -700 {lab=Source[20]}
N 31460 -650 31650 -650 {lab=Source[20]}
N 31650 -1140 33150 -1140 {lab=Sforce}
N 31650 -1140 31650 -960 {lab=Sforce}
N 31560 -960 31650 -960 {lab=Sforce}
N 31280 -1170 32780 -1170 {lab=Ssense}
N 31280 -1170 31280 -960 {lab=Ssense}
N 31190 -960 31280 -960 {lab=Ssense}
N 30780 -1200 32280 -1200 {lab=Gdrive}
N 30780 -1200 30780 -960 {lab=Gdrive}
N 30690 -960 30780 -960 {lab=Gdrive}
N 31000 -1230 32500 -1230 {lab=Vcl}
N 31000 -1230 31000 -850 {lab=Vcl}
N 31240 -1380 31240 -1350 {lab=ctrl_p[20]}
N 31110 -1350 31240 -1350 {lab=ctrl_p[20]}
N 30610 -1350 30610 -820 {lab=ctrl_p[20]}
N 30610 -820 30650 -820 {lab=ctrl_p[20]}
N 31110 -820 31150 -820 {lab=ctrl_p[20]}
N 31110 -1350 31110 -820 {lab=ctrl_p[20]}
N 30610 -1350 31110 -1350 {lab=ctrl_p[20]}
N 30940 -1320 30940 -820 {lab=ctrl_n[20]}
N 30900 -820 30940 -820 {lab=ctrl_n[20]}
N 30940 -1320 31290 -1320 {lab=ctrl_n[20]}
N 31290 -1380 31290 -1320 {lab=ctrl_n[20]}
N 31400 -820 31440 -820 {lab=ctrl_n[20]}
N 31480 -820 31520 -820 {lab=ctrl_p[20]}
N 31440 -1320 31800 -1320 {lab=ctrl_n[20]}
N 31440 -1320 31440 -820 {lab=ctrl_n[20]}
N 31290 -1320 31440 -1320 {lab=ctrl_n[20]}
N 31240 -1350 31480 -1350 {lab=ctrl_p[20]}
N 31480 -1350 31480 -820 {lab=ctrl_p[20]}
N 31800 -1320 31800 -820 {lab=ctrl_n[20]}
N 31770 -820 31800 -820 {lab=ctrl_n[20]}
N 31460 -650 31460 -580 {lab=Source[20]}
N 31280 -650 31460 -650 {lab=Source[20]}
N 30690 -820 30730 -820 {lab=#net141}
N 30730 -820 30730 -460 {lab=#net141}
N 31000 -820 31040 -820 {lab=#net142}
N 31040 -820 31040 -460 {lab=#net142}
N 30730 -400 30730 -330 {lab=Vss}
N 31600 -330 31900 -330 {lab=Vss}
N 31900 -1080 31900 -330 {lab=Vss}
N 31900 -1080 33400 -1080 {lab=Vss}
N 31870 -1110 33370 -1110 {lab=1.2V}
N 31870 -1110 31870 -360 {lab=1.2V}
N 31040 -400 31040 -330 {lab=Vss}
N 30730 -330 31040 -330 {lab=Vss}
N 31690 -360 31870 -360 {lab=1.2V}
N 31320 -820 31360 -820 {lab=#net143}
N 31320 -820 31320 -460 {lab=#net143}
N 31190 -820 31230 -820 {lab=#net144}
N 31230 -820 31230 -460 {lab=#net144}
N 31320 -400 31320 -360 {lab=1.2V}
N 31230 -400 31230 -330 {lab=Vss}
N 31040 -330 31230 -330 {lab=Vss}
N 30810 -820 30860 -820 {lab=#net145}
N 30810 -820 30810 -460 {lab=#net145}
N 30810 -400 30810 -360 {lab=1.2V}
N 30810 -360 31320 -360 {lab=1.2V}
N 31560 -820 31600 -820 {lab=#net146}
N 31600 -820 31600 -460 {lab=#net146}
N 31690 -820 31730 -820 {lab=#net147}
N 31690 -820 31690 -460 {lab=#net147}
N 31690 -400 31690 -360 {lab=1.2V}
N 31320 -360 31690 -360 {lab=1.2V}
N 31600 -400 31600 -330 {lab=Vss}
N 31230 -330 31600 -330 {lab=Vss}
N 32190 -960 32190 -850 {lab=Gdrive}
N 32280 -960 32360 -960 {lab=Gdrive}
N 32360 -960 32360 -850 {lab=Gdrive}
N 32190 -790 32190 -700 {lab=Gate[21]}
N 32280 -700 32360 -700 {lab=Gate[21]}
N 32360 -790 32360 -700 {lab=Gate[21]}
N 32500 -790 32500 -650 {lab=Gate[21]}
N 32390 -650 32500 -650 {lab=Gate[21]}
N 32280 -700 32280 -650 {lab=Gate[21]}
N 32190 -700 32280 -700 {lab=Gate[21]}
N 32390 -650 32390 -570 {lab=Gate[21]}
N 32280 -650 32390 -650 {lab=Gate[21]}
N 32440 -820 32460 -820 {lab=ctrl_n[21]}
N 32690 -960 32690 -850 {lab=Ssense}
N 32780 -960 32860 -960 {lab=Ssense}
N 32860 -960 32860 -850 {lab=Ssense}
N 32690 -790 32690 -700 {lab=Source[21]}
N 32780 -700 32860 -700 {lab=Source[21]}
N 32860 -790 32860 -700 {lab=Source[21]}
N 32780 -700 32780 -650 {lab=Source[21]}
N 32690 -700 32780 -700 {lab=Source[21]}
N 33060 -960 33060 -850 {lab=Sforce}
N 33150 -960 33230 -960 {lab=Sforce}
N 33230 -960 33230 -850 {lab=Sforce}
N 33060 -790 33060 -700 {lab=Source[21]}
N 33150 -700 33230 -700 {lab=Source[21]}
N 33230 -790 33230 -700 {lab=Source[21]}
N 33150 -700 33150 -650 {lab=Source[21]}
N 33060 -700 33150 -700 {lab=Source[21]}
N 32960 -650 33150 -650 {lab=Source[21]}
N 33150 -1140 34650 -1140 {lab=Sforce}
N 33150 -1140 33150 -960 {lab=Sforce}
N 33060 -960 33150 -960 {lab=Sforce}
N 32780 -1170 34280 -1170 {lab=Ssense}
N 32780 -1170 32780 -960 {lab=Ssense}
N 32690 -960 32780 -960 {lab=Ssense}
N 32280 -1200 33780 -1200 {lab=Gdrive}
N 32280 -1200 32280 -960 {lab=Gdrive}
N 32190 -960 32280 -960 {lab=Gdrive}
N 32500 -1230 34000 -1230 {lab=Vcl}
N 32500 -1230 32500 -850 {lab=Vcl}
N 32740 -1380 32740 -1350 {lab=ctrl_p[21]}
N 32610 -1350 32740 -1350 {lab=ctrl_p[21]}
N 32110 -1350 32110 -820 {lab=ctrl_p[21]}
N 32110 -820 32150 -820 {lab=ctrl_p[21]}
N 32610 -820 32650 -820 {lab=ctrl_p[21]}
N 32610 -1350 32610 -820 {lab=ctrl_p[21]}
N 32110 -1350 32610 -1350 {lab=ctrl_p[21]}
N 32440 -1320 32440 -820 {lab=ctrl_n[21]}
N 32400 -820 32440 -820 {lab=ctrl_n[21]}
N 32440 -1320 32790 -1320 {lab=ctrl_n[21]}
N 32790 -1380 32790 -1320 {lab=ctrl_n[21]}
N 32900 -820 32940 -820 {lab=ctrl_n[21]}
N 32980 -820 33020 -820 {lab=ctrl_p[21]}
N 32940 -1320 33300 -1320 {lab=ctrl_n[21]}
N 32940 -1320 32940 -820 {lab=ctrl_n[21]}
N 32790 -1320 32940 -1320 {lab=ctrl_n[21]}
N 32740 -1350 32980 -1350 {lab=ctrl_p[21]}
N 32980 -1350 32980 -820 {lab=ctrl_p[21]}
N 33300 -1320 33300 -820 {lab=ctrl_n[21]}
N 33270 -820 33300 -820 {lab=ctrl_n[21]}
N 32960 -650 32960 -580 {lab=Source[21]}
N 32780 -650 32960 -650 {lab=Source[21]}
N 32190 -820 32230 -820 {lab=#net148}
N 32230 -820 32230 -460 {lab=#net148}
N 32500 -820 32540 -820 {lab=#net149}
N 32540 -820 32540 -460 {lab=#net149}
N 32230 -400 32230 -330 {lab=Vss}
N 33100 -330 33400 -330 {lab=Vss}
N 33400 -1080 33400 -330 {lab=Vss}
N 33400 -1080 34900 -1080 {lab=Vss}
N 33370 -1110 34870 -1110 {lab=1.2V}
N 33370 -1110 33370 -360 {lab=1.2V}
N 32540 -400 32540 -330 {lab=Vss}
N 32230 -330 32540 -330 {lab=Vss}
N 33190 -360 33370 -360 {lab=1.2V}
N 32820 -820 32860 -820 {lab=#net150}
N 32820 -820 32820 -460 {lab=#net150}
N 32690 -820 32730 -820 {lab=#net151}
N 32730 -820 32730 -460 {lab=#net151}
N 32820 -400 32820 -360 {lab=1.2V}
N 32730 -400 32730 -330 {lab=Vss}
N 32540 -330 32730 -330 {lab=Vss}
N 32310 -820 32360 -820 {lab=#net152}
N 32310 -820 32310 -460 {lab=#net152}
N 32310 -400 32310 -360 {lab=1.2V}
N 32310 -360 32820 -360 {lab=1.2V}
N 33060 -820 33100 -820 {lab=#net153}
N 33100 -820 33100 -460 {lab=#net153}
N 33190 -820 33230 -820 {lab=#net154}
N 33190 -820 33190 -460 {lab=#net154}
N 33190 -400 33190 -360 {lab=1.2V}
N 32820 -360 33190 -360 {lab=1.2V}
N 33100 -400 33100 -330 {lab=Vss}
N 32730 -330 33100 -330 {lab=Vss}
N 33690 -960 33690 -850 {lab=Gdrive}
N 33780 -960 33860 -960 {lab=Gdrive}
N 33860 -960 33860 -850 {lab=Gdrive}
N 33690 -790 33690 -700 {lab=Gate[22]}
N 33780 -700 33860 -700 {lab=Gate[22]}
N 33860 -790 33860 -700 {lab=Gate[22]}
N 34000 -790 34000 -650 {lab=Gate[22]}
N 33890 -650 34000 -650 {lab=Gate[22]}
N 33780 -700 33780 -650 {lab=Gate[22]}
N 33690 -700 33780 -700 {lab=Gate[22]}
N 33890 -650 33890 -570 {lab=Gate[22]}
N 33780 -650 33890 -650 {lab=Gate[22]}
N 33940 -820 33960 -820 {lab=ctrl_n[22]}
N 34190 -960 34190 -850 {lab=Ssense}
N 34280 -960 34360 -960 {lab=Ssense}
N 34360 -960 34360 -850 {lab=Ssense}
N 34190 -790 34190 -700 {lab=Source[22]}
N 34280 -700 34360 -700 {lab=Source[22]}
N 34360 -790 34360 -700 {lab=Source[22]}
N 34280 -700 34280 -650 {lab=Source[22]}
N 34190 -700 34280 -700 {lab=Source[22]}
N 34560 -960 34560 -850 {lab=Sforce}
N 34650 -960 34730 -960 {lab=Sforce}
N 34730 -960 34730 -850 {lab=Sforce}
N 34560 -790 34560 -700 {lab=Source[22]}
N 34650 -700 34730 -700 {lab=Source[22]}
N 34730 -790 34730 -700 {lab=Source[22]}
N 34650 -700 34650 -650 {lab=Source[22]}
N 34560 -700 34650 -700 {lab=Source[22]}
N 34460 -650 34650 -650 {lab=Source[22]}
N 34650 -1140 36150 -1140 {lab=Sforce}
N 34650 -1140 34650 -960 {lab=Sforce}
N 34560 -960 34650 -960 {lab=Sforce}
N 34280 -1170 35780 -1170 {lab=Ssense}
N 34280 -1170 34280 -960 {lab=Ssense}
N 34190 -960 34280 -960 {lab=Ssense}
N 33780 -1200 35280 -1200 {lab=Gdrive}
N 33780 -1200 33780 -960 {lab=Gdrive}
N 33690 -960 33780 -960 {lab=Gdrive}
N 34000 -1230 35500 -1230 {lab=Vcl}
N 34000 -1230 34000 -850 {lab=Vcl}
N 34240 -1380 34240 -1350 {lab=ctrl_p[22]}
N 34110 -1350 34240 -1350 {lab=ctrl_p[22]}
N 33610 -1350 33610 -820 {lab=ctrl_p[22]}
N 33610 -820 33650 -820 {lab=ctrl_p[22]}
N 34110 -820 34150 -820 {lab=ctrl_p[22]}
N 34110 -1350 34110 -820 {lab=ctrl_p[22]}
N 33610 -1350 34110 -1350 {lab=ctrl_p[22]}
N 33940 -1320 33940 -820 {lab=ctrl_n[22]}
N 33900 -820 33940 -820 {lab=ctrl_n[22]}
N 33940 -1320 34290 -1320 {lab=ctrl_n[22]}
N 34290 -1380 34290 -1320 {lab=ctrl_n[22]}
N 34400 -820 34440 -820 {lab=ctrl_n[22]}
N 34480 -820 34520 -820 {lab=ctrl_p[22]}
N 34440 -1320 34800 -1320 {lab=ctrl_n[22]}
N 34440 -1320 34440 -820 {lab=ctrl_n[22]}
N 34290 -1320 34440 -1320 {lab=ctrl_n[22]}
N 34240 -1350 34480 -1350 {lab=ctrl_p[22]}
N 34480 -1350 34480 -820 {lab=ctrl_p[22]}
N 34800 -1320 34800 -820 {lab=ctrl_n[22]}
N 34770 -820 34800 -820 {lab=ctrl_n[22]}
N 34460 -650 34460 -580 {lab=Source[22]}
N 34280 -650 34460 -650 {lab=Source[22]}
N 33690 -820 33730 -820 {lab=#net155}
N 33730 -820 33730 -460 {lab=#net155}
N 34000 -820 34040 -820 {lab=#net156}
N 34040 -820 34040 -460 {lab=#net156}
N 33730 -400 33730 -330 {lab=Vss}
N 34600 -330 34900 -330 {lab=Vss}
N 34900 -1080 34900 -330 {lab=Vss}
N 34900 -1080 36400 -1080 {lab=Vss}
N 34870 -1110 36370 -1110 {lab=1.2V}
N 34870 -1110 34870 -360 {lab=1.2V}
N 34040 -400 34040 -330 {lab=Vss}
N 33730 -330 34040 -330 {lab=Vss}
N 34690 -360 34870 -360 {lab=1.2V}
N 34320 -820 34360 -820 {lab=#net157}
N 34320 -820 34320 -460 {lab=#net157}
N 34190 -820 34230 -820 {lab=#net158}
N 34230 -820 34230 -460 {lab=#net158}
N 34320 -400 34320 -360 {lab=1.2V}
N 34230 -400 34230 -330 {lab=Vss}
N 34040 -330 34230 -330 {lab=Vss}
N 33810 -820 33860 -820 {lab=#net159}
N 33810 -820 33810 -460 {lab=#net159}
N 33810 -400 33810 -360 {lab=1.2V}
N 33810 -360 34320 -360 {lab=1.2V}
N 34560 -820 34600 -820 {lab=#net160}
N 34600 -820 34600 -460 {lab=#net160}
N 34690 -820 34730 -820 {lab=#net161}
N 34690 -820 34690 -460 {lab=#net161}
N 34690 -400 34690 -360 {lab=1.2V}
N 34320 -360 34690 -360 {lab=1.2V}
N 34600 -400 34600 -330 {lab=Vss}
N 34230 -330 34600 -330 {lab=Vss}
N 35190 -960 35190 -850 {lab=Gdrive}
N 35280 -960 35360 -960 {lab=Gdrive}
N 35360 -960 35360 -850 {lab=Gdrive}
N 35190 -790 35190 -700 {lab=Gate[23]}
N 35280 -700 35360 -700 {lab=Gate[23]}
N 35360 -790 35360 -700 {lab=Gate[23]}
N 35500 -790 35500 -650 {lab=Gate[23]}
N 35390 -650 35500 -650 {lab=Gate[23]}
N 35280 -700 35280 -650 {lab=Gate[23]}
N 35190 -700 35280 -700 {lab=Gate[23]}
N 35390 -650 35390 -570 {lab=Gate[23]}
N 35280 -650 35390 -650 {lab=Gate[23]}
N 35440 -820 35460 -820 {lab=ctrl_n[23]}
N 35690 -960 35690 -850 {lab=Ssense}
N 35780 -960 35860 -960 {lab=Ssense}
N 35860 -960 35860 -850 {lab=Ssense}
N 35690 -790 35690 -700 {lab=Source[23]}
N 35780 -700 35860 -700 {lab=Source[23]}
N 35860 -790 35860 -700 {lab=Source[23]}
N 35780 -700 35780 -650 {lab=Source[23]}
N 35690 -700 35780 -700 {lab=Source[23]}
N 36060 -960 36060 -850 {lab=Sforce}
N 36150 -960 36230 -960 {lab=Sforce}
N 36230 -960 36230 -850 {lab=Sforce}
N 36060 -790 36060 -700 {lab=Source[23]}
N 36150 -700 36230 -700 {lab=Source[23]}
N 36230 -790 36230 -700 {lab=Source[23]}
N 36150 -700 36150 -650 {lab=Source[23]}
N 36060 -700 36150 -700 {lab=Source[23]}
N 35960 -650 36150 -650 {lab=Source[23]}
N 36150 -1140 37650 -1140 {lab=Sforce}
N 36150 -1140 36150 -960 {lab=Sforce}
N 36060 -960 36150 -960 {lab=Sforce}
N 35780 -1170 37280 -1170 {lab=Ssense}
N 35780 -1170 35780 -960 {lab=Ssense}
N 35690 -960 35780 -960 {lab=Ssense}
N 35280 -1200 36780 -1200 {lab=Gdrive}
N 35280 -1200 35280 -960 {lab=Gdrive}
N 35190 -960 35280 -960 {lab=Gdrive}
N 35500 -1230 37000 -1230 {lab=Vcl}
N 35500 -1230 35500 -850 {lab=Vcl}
N 35740 -1380 35740 -1350 {lab=ctrl_p[23]}
N 35610 -1350 35740 -1350 {lab=ctrl_p[23]}
N 35110 -1350 35110 -820 {lab=ctrl_p[23]}
N 35110 -820 35150 -820 {lab=ctrl_p[23]}
N 35610 -820 35650 -820 {lab=ctrl_p[23]}
N 35610 -1350 35610 -820 {lab=ctrl_p[23]}
N 35110 -1350 35610 -1350 {lab=ctrl_p[23]}
N 35440 -1320 35440 -820 {lab=ctrl_n[23]}
N 35400 -820 35440 -820 {lab=ctrl_n[23]}
N 35440 -1320 35790 -1320 {lab=ctrl_n[23]}
N 35790 -1380 35790 -1320 {lab=ctrl_n[23]}
N 35900 -820 35940 -820 {lab=ctrl_n[23]}
N 35980 -820 36020 -820 {lab=ctrl_p[23]}
N 35940 -1320 36300 -1320 {lab=ctrl_n[23]}
N 35940 -1320 35940 -820 {lab=ctrl_n[23]}
N 35790 -1320 35940 -1320 {lab=ctrl_n[23]}
N 35740 -1350 35980 -1350 {lab=ctrl_p[23]}
N 35980 -1350 35980 -820 {lab=ctrl_p[23]}
N 36300 -1320 36300 -820 {lab=ctrl_n[23]}
N 36270 -820 36300 -820 {lab=ctrl_n[23]}
N 35960 -650 35960 -580 {lab=Source[23]}
N 35780 -650 35960 -650 {lab=Source[23]}
N 35190 -820 35230 -820 {lab=#net162}
N 35230 -820 35230 -460 {lab=#net162}
N 35500 -820 35540 -820 {lab=#net163}
N 35540 -820 35540 -460 {lab=#net163}
N 35230 -400 35230 -330 {lab=Vss}
N 36100 -330 36400 -330 {lab=Vss}
N 36400 -1080 36400 -330 {lab=Vss}
N 36400 -1080 37900 -1080 {lab=Vss}
N 36370 -1110 37870 -1110 {lab=1.2V}
N 36370 -1110 36370 -360 {lab=1.2V}
N 35540 -400 35540 -330 {lab=Vss}
N 35230 -330 35540 -330 {lab=Vss}
N 36190 -360 36370 -360 {lab=1.2V}
N 35820 -820 35860 -820 {lab=#net164}
N 35820 -820 35820 -460 {lab=#net164}
N 35690 -820 35730 -820 {lab=#net165}
N 35730 -820 35730 -460 {lab=#net165}
N 35820 -400 35820 -360 {lab=1.2V}
N 35730 -400 35730 -330 {lab=Vss}
N 35540 -330 35730 -330 {lab=Vss}
N 35310 -820 35360 -820 {lab=#net166}
N 35310 -820 35310 -460 {lab=#net166}
N 35310 -400 35310 -360 {lab=1.2V}
N 35310 -360 35820 -360 {lab=1.2V}
N 36060 -820 36100 -820 {lab=#net167}
N 36100 -820 36100 -460 {lab=#net167}
N 36190 -820 36230 -820 {lab=#net168}
N 36190 -820 36190 -460 {lab=#net168}
N 36190 -400 36190 -360 {lab=1.2V}
N 35820 -360 36190 -360 {lab=1.2V}
N 36100 -400 36100 -330 {lab=Vss}
N 35730 -330 36100 -330 {lab=Vss}
N 36690 -960 36690 -850 {lab=Gdrive}
N 36780 -960 36860 -960 {lab=Gdrive}
N 36860 -960 36860 -850 {lab=Gdrive}
N 36690 -790 36690 -700 {lab=Gate[24]}
N 36780 -700 36860 -700 {lab=Gate[24]}
N 36860 -790 36860 -700 {lab=Gate[24]}
N 37000 -790 37000 -650 {lab=Gate[24]}
N 36890 -650 37000 -650 {lab=Gate[24]}
N 36780 -700 36780 -650 {lab=Gate[24]}
N 36690 -700 36780 -700 {lab=Gate[24]}
N 36890 -650 36890 -570 {lab=Gate[24]}
N 36780 -650 36890 -650 {lab=Gate[24]}
N 36940 -820 36960 -820 {lab=ctrl_n[24]}
N 37190 -960 37190 -850 {lab=Ssense}
N 37280 -960 37360 -960 {lab=Ssense}
N 37360 -960 37360 -850 {lab=Ssense}
N 37190 -790 37190 -700 {lab=Source[24]}
N 37280 -700 37360 -700 {lab=Source[24]}
N 37360 -790 37360 -700 {lab=Source[24]}
N 37280 -700 37280 -650 {lab=Source[24]}
N 37190 -700 37280 -700 {lab=Source[24]}
N 37560 -960 37560 -850 {lab=Sforce}
N 37650 -960 37730 -960 {lab=Sforce}
N 37730 -960 37730 -850 {lab=Sforce}
N 37560 -790 37560 -700 {lab=Source[24]}
N 37650 -700 37730 -700 {lab=Source[24]}
N 37730 -790 37730 -700 {lab=Source[24]}
N 37650 -700 37650 -650 {lab=Source[24]}
N 37560 -700 37650 -700 {lab=Source[24]}
N 37460 -650 37650 -650 {lab=Source[24]}
N 37650 -1140 39150 -1140 {lab=Sforce}
N 37650 -1140 37650 -960 {lab=Sforce}
N 37560 -960 37650 -960 {lab=Sforce}
N 37280 -1170 38780 -1170 {lab=Ssense}
N 37280 -1170 37280 -960 {lab=Ssense}
N 37190 -960 37280 -960 {lab=Ssense}
N 36780 -1200 38280 -1200 {lab=Gdrive}
N 36780 -1200 36780 -960 {lab=Gdrive}
N 36690 -960 36780 -960 {lab=Gdrive}
N 37000 -1230 38500 -1230 {lab=Vcl}
N 37000 -1230 37000 -850 {lab=Vcl}
N 37240 -1380 37240 -1350 {lab=ctrl_p[24]}
N 37110 -1350 37240 -1350 {lab=ctrl_p[24]}
N 36610 -1350 36610 -820 {lab=ctrl_p[24]}
N 36610 -820 36650 -820 {lab=ctrl_p[24]}
N 37110 -820 37150 -820 {lab=ctrl_p[24]}
N 37110 -1350 37110 -820 {lab=ctrl_p[24]}
N 36610 -1350 37110 -1350 {lab=ctrl_p[24]}
N 36940 -1320 36940 -820 {lab=ctrl_n[24]}
N 36900 -820 36940 -820 {lab=ctrl_n[24]}
N 36940 -1320 37290 -1320 {lab=ctrl_n[24]}
N 37290 -1380 37290 -1320 {lab=ctrl_n[24]}
N 37400 -820 37440 -820 {lab=ctrl_n[24]}
N 37480 -820 37520 -820 {lab=ctrl_p[24]}
N 37440 -1320 37800 -1320 {lab=ctrl_n[24]}
N 37440 -1320 37440 -820 {lab=ctrl_n[24]}
N 37290 -1320 37440 -1320 {lab=ctrl_n[24]}
N 37240 -1350 37480 -1350 {lab=ctrl_p[24]}
N 37480 -1350 37480 -820 {lab=ctrl_p[24]}
N 37800 -1320 37800 -820 {lab=ctrl_n[24]}
N 37770 -820 37800 -820 {lab=ctrl_n[24]}
N 37460 -650 37460 -580 {lab=Source[24]}
N 37280 -650 37460 -650 {lab=Source[24]}
N 36690 -820 36730 -820 {lab=#net169}
N 36730 -820 36730 -460 {lab=#net169}
N 37000 -820 37040 -820 {lab=#net170}
N 37040 -820 37040 -460 {lab=#net170}
N 36730 -400 36730 -330 {lab=Vss}
N 37600 -330 37900 -330 {lab=Vss}
N 37900 -1080 37900 -330 {lab=Vss}
N 37900 -1080 39400 -1080 {lab=Vss}
N 37870 -1110 39370 -1110 {lab=1.2V}
N 37870 -1110 37870 -360 {lab=1.2V}
N 37040 -400 37040 -330 {lab=Vss}
N 36730 -330 37040 -330 {lab=Vss}
N 37690 -360 37870 -360 {lab=1.2V}
N 37320 -820 37360 -820 {lab=#net171}
N 37320 -820 37320 -460 {lab=#net171}
N 37190 -820 37230 -820 {lab=#net172}
N 37230 -820 37230 -460 {lab=#net172}
N 37320 -400 37320 -360 {lab=1.2V}
N 37230 -400 37230 -330 {lab=Vss}
N 37040 -330 37230 -330 {lab=Vss}
N 36810 -820 36860 -820 {lab=#net173}
N 36810 -820 36810 -460 {lab=#net173}
N 36810 -400 36810 -360 {lab=1.2V}
N 36810 -360 37320 -360 {lab=1.2V}
N 37560 -820 37600 -820 {lab=#net174}
N 37600 -820 37600 -460 {lab=#net174}
N 37690 -820 37730 -820 {lab=#net175}
N 37690 -820 37690 -460 {lab=#net175}
N 37690 -400 37690 -360 {lab=1.2V}
N 37320 -360 37690 -360 {lab=1.2V}
N 37600 -400 37600 -330 {lab=Vss}
N 37230 -330 37600 -330 {lab=Vss}
N 38190 -960 38190 -850 {lab=Gdrive}
N 38280 -960 38360 -960 {lab=Gdrive}
N 38360 -960 38360 -850 {lab=Gdrive}
N 38190 -790 38190 -700 {lab=Gate[25]}
N 38280 -700 38360 -700 {lab=Gate[25]}
N 38360 -790 38360 -700 {lab=Gate[25]}
N 38500 -790 38500 -650 {lab=Gate[25]}
N 38390 -650 38500 -650 {lab=Gate[25]}
N 38280 -700 38280 -650 {lab=Gate[25]}
N 38190 -700 38280 -700 {lab=Gate[25]}
N 38390 -650 38390 -570 {lab=Gate[25]}
N 38280 -650 38390 -650 {lab=Gate[25]}
N 38440 -820 38460 -820 {lab=ctrl_n[25]}
N 38690 -960 38690 -850 {lab=Ssense}
N 38780 -960 38860 -960 {lab=Ssense}
N 38860 -960 38860 -850 {lab=Ssense}
N 38690 -790 38690 -700 {lab=Source[25]}
N 38780 -700 38860 -700 {lab=Source[25]}
N 38860 -790 38860 -700 {lab=Source[25]}
N 38780 -700 38780 -650 {lab=Source[25]}
N 38690 -700 38780 -700 {lab=Source[25]}
N 39060 -960 39060 -850 {lab=Sforce}
N 39150 -960 39230 -960 {lab=Sforce}
N 39230 -960 39230 -850 {lab=Sforce}
N 39060 -790 39060 -700 {lab=Source[25]}
N 39150 -700 39230 -700 {lab=Source[25]}
N 39230 -790 39230 -700 {lab=Source[25]}
N 39150 -700 39150 -650 {lab=Source[25]}
N 39060 -700 39150 -700 {lab=Source[25]}
N 38960 -650 39150 -650 {lab=Source[25]}
N 39150 -1140 40650 -1140 {lab=Sforce}
N 39150 -1140 39150 -960 {lab=Sforce}
N 39060 -960 39150 -960 {lab=Sforce}
N 38780 -1170 40280 -1170 {lab=Ssense}
N 38780 -1170 38780 -960 {lab=Ssense}
N 38690 -960 38780 -960 {lab=Ssense}
N 38280 -1200 39780 -1200 {lab=Gdrive}
N 38280 -1200 38280 -960 {lab=Gdrive}
N 38190 -960 38280 -960 {lab=Gdrive}
N 38500 -1230 40000 -1230 {lab=Vcl}
N 38500 -1230 38500 -850 {lab=Vcl}
N 38740 -1380 38740 -1350 {lab=ctrl_p[25]}
N 38610 -1350 38740 -1350 {lab=ctrl_p[25]}
N 38110 -1350 38110 -820 {lab=ctrl_p[25]}
N 38110 -820 38150 -820 {lab=ctrl_p[25]}
N 38610 -820 38650 -820 {lab=ctrl_p[25]}
N 38610 -1350 38610 -820 {lab=ctrl_p[25]}
N 38110 -1350 38610 -1350 {lab=ctrl_p[25]}
N 38440 -1320 38440 -820 {lab=ctrl_n[25]}
N 38400 -820 38440 -820 {lab=ctrl_n[25]}
N 38440 -1320 38790 -1320 {lab=ctrl_n[25]}
N 38790 -1380 38790 -1320 {lab=ctrl_n[25]}
N 38900 -820 38940 -820 {lab=ctrl_n[25]}
N 38980 -820 39020 -820 {lab=ctrl_p[25]}
N 38940 -1320 39300 -1320 {lab=ctrl_n[25]}
N 38940 -1320 38940 -820 {lab=ctrl_n[25]}
N 38790 -1320 38940 -1320 {lab=ctrl_n[25]}
N 38740 -1350 38980 -1350 {lab=ctrl_p[25]}
N 38980 -1350 38980 -820 {lab=ctrl_p[25]}
N 39300 -1320 39300 -820 {lab=ctrl_n[25]}
N 39270 -820 39300 -820 {lab=ctrl_n[25]}
N 38960 -650 38960 -580 {lab=Source[25]}
N 38780 -650 38960 -650 {lab=Source[25]}
N 38190 -820 38230 -820 {lab=#net176}
N 38230 -820 38230 -460 {lab=#net176}
N 38500 -820 38540 -820 {lab=#net177}
N 38540 -820 38540 -460 {lab=#net177}
N 38230 -400 38230 -330 {lab=Vss}
N 39100 -330 39400 -330 {lab=Vss}
N 39400 -1080 39400 -330 {lab=Vss}
N 39400 -1080 40900 -1080 {lab=Vss}
N 39370 -1110 40870 -1110 {lab=1.2V}
N 39370 -1110 39370 -360 {lab=1.2V}
N 38540 -400 38540 -330 {lab=Vss}
N 38230 -330 38540 -330 {lab=Vss}
N 39190 -360 39370 -360 {lab=1.2V}
N 38820 -820 38860 -820 {lab=#net178}
N 38820 -820 38820 -460 {lab=#net178}
N 38690 -820 38730 -820 {lab=#net179}
N 38730 -820 38730 -460 {lab=#net179}
N 38820 -400 38820 -360 {lab=1.2V}
N 38730 -400 38730 -330 {lab=Vss}
N 38540 -330 38730 -330 {lab=Vss}
N 38310 -820 38360 -820 {lab=#net180}
N 38310 -820 38310 -460 {lab=#net180}
N 38310 -400 38310 -360 {lab=1.2V}
N 38310 -360 38820 -360 {lab=1.2V}
N 39060 -820 39100 -820 {lab=#net181}
N 39100 -820 39100 -460 {lab=#net181}
N 39190 -820 39230 -820 {lab=#net182}
N 39190 -820 39190 -460 {lab=#net182}
N 39190 -400 39190 -360 {lab=1.2V}
N 38820 -360 39190 -360 {lab=1.2V}
N 39100 -400 39100 -330 {lab=Vss}
N 38730 -330 39100 -330 {lab=Vss}
N 39690 -960 39690 -850 {lab=Gdrive}
N 39780 -960 39860 -960 {lab=Gdrive}
N 39860 -960 39860 -850 {lab=Gdrive}
N 39690 -790 39690 -700 {lab=Gate[26]}
N 39780 -700 39860 -700 {lab=Gate[26]}
N 39860 -790 39860 -700 {lab=Gate[26]}
N 40000 -790 40000 -650 {lab=Gate[26]}
N 39890 -650 40000 -650 {lab=Gate[26]}
N 39780 -700 39780 -650 {lab=Gate[26]}
N 39690 -700 39780 -700 {lab=Gate[26]}
N 39890 -650 39890 -570 {lab=Gate[26]}
N 39780 -650 39890 -650 {lab=Gate[26]}
N 39940 -820 39960 -820 {lab=ctrl_n[26]}
N 40190 -960 40190 -850 {lab=Ssense}
N 40280 -960 40360 -960 {lab=Ssense}
N 40360 -960 40360 -850 {lab=Ssense}
N 40190 -790 40190 -700 {lab=Source[26]}
N 40280 -700 40360 -700 {lab=Source[26]}
N 40360 -790 40360 -700 {lab=Source[26]}
N 40280 -700 40280 -650 {lab=Source[26]}
N 40190 -700 40280 -700 {lab=Source[26]}
N 40560 -960 40560 -850 {lab=Sforce}
N 40650 -960 40730 -960 {lab=Sforce}
N 40730 -960 40730 -850 {lab=Sforce}
N 40560 -790 40560 -700 {lab=Source[26]}
N 40650 -700 40730 -700 {lab=Source[26]}
N 40730 -790 40730 -700 {lab=Source[26]}
N 40650 -700 40650 -650 {lab=Source[26]}
N 40560 -700 40650 -700 {lab=Source[26]}
N 40460 -650 40650 -650 {lab=Source[26]}
N 40650 -1140 42150 -1140 {lab=Sforce}
N 40650 -1140 40650 -960 {lab=Sforce}
N 40560 -960 40650 -960 {lab=Sforce}
N 40280 -1170 41780 -1170 {lab=Ssense}
N 40280 -1170 40280 -960 {lab=Ssense}
N 40190 -960 40280 -960 {lab=Ssense}
N 39780 -1200 41280 -1200 {lab=Gdrive}
N 39780 -1200 39780 -960 {lab=Gdrive}
N 39690 -960 39780 -960 {lab=Gdrive}
N 40000 -1230 41500 -1230 {lab=Vcl}
N 40000 -1230 40000 -850 {lab=Vcl}
N 40240 -1380 40240 -1350 {lab=ctrl_p[26]}
N 40110 -1350 40240 -1350 {lab=ctrl_p[26]}
N 39610 -1350 39610 -820 {lab=ctrl_p[26]}
N 39610 -820 39650 -820 {lab=ctrl_p[26]}
N 40110 -820 40150 -820 {lab=ctrl_p[26]}
N 40110 -1350 40110 -820 {lab=ctrl_p[26]}
N 39610 -1350 40110 -1350 {lab=ctrl_p[26]}
N 39940 -1320 39940 -820 {lab=ctrl_n[26]}
N 39900 -820 39940 -820 {lab=ctrl_n[26]}
N 39940 -1320 40290 -1320 {lab=ctrl_n[26]}
N 40290 -1380 40290 -1320 {lab=ctrl_n[26]}
N 40400 -820 40440 -820 {lab=ctrl_n[26]}
N 40480 -820 40520 -820 {lab=ctrl_p[26]}
N 40440 -1320 40800 -1320 {lab=ctrl_n[26]}
N 40440 -1320 40440 -820 {lab=ctrl_n[26]}
N 40290 -1320 40440 -1320 {lab=ctrl_n[26]}
N 40240 -1350 40480 -1350 {lab=ctrl_p[26]}
N 40480 -1350 40480 -820 {lab=ctrl_p[26]}
N 40800 -1320 40800 -820 {lab=ctrl_n[26]}
N 40770 -820 40800 -820 {lab=ctrl_n[26]}
N 40460 -650 40460 -580 {lab=Source[26]}
N 40280 -650 40460 -650 {lab=Source[26]}
N 39690 -820 39730 -820 {lab=#net183}
N 39730 -820 39730 -460 {lab=#net183}
N 40000 -820 40040 -820 {lab=#net184}
N 40040 -820 40040 -460 {lab=#net184}
N 39730 -400 39730 -330 {lab=Vss}
N 40600 -330 40900 -330 {lab=Vss}
N 40900 -1080 40900 -330 {lab=Vss}
N 40900 -1080 42400 -1080 {lab=Vss}
N 40870 -1110 42370 -1110 {lab=1.2V}
N 40870 -1110 40870 -360 {lab=1.2V}
N 40040 -400 40040 -330 {lab=Vss}
N 39730 -330 40040 -330 {lab=Vss}
N 40690 -360 40870 -360 {lab=1.2V}
N 40320 -820 40360 -820 {lab=#net185}
N 40320 -820 40320 -460 {lab=#net185}
N 40190 -820 40230 -820 {lab=#net186}
N 40230 -820 40230 -460 {lab=#net186}
N 40320 -400 40320 -360 {lab=1.2V}
N 40230 -400 40230 -330 {lab=Vss}
N 40040 -330 40230 -330 {lab=Vss}
N 39810 -820 39860 -820 {lab=#net187}
N 39810 -820 39810 -460 {lab=#net187}
N 39810 -400 39810 -360 {lab=1.2V}
N 39810 -360 40320 -360 {lab=1.2V}
N 40560 -820 40600 -820 {lab=#net188}
N 40600 -820 40600 -460 {lab=#net188}
N 40690 -820 40730 -820 {lab=#net189}
N 40690 -820 40690 -460 {lab=#net189}
N 40690 -400 40690 -360 {lab=1.2V}
N 40320 -360 40690 -360 {lab=1.2V}
N 40600 -400 40600 -330 {lab=Vss}
N 40230 -330 40600 -330 {lab=Vss}
N 41190 -960 41190 -850 {lab=Gdrive}
N 41280 -960 41360 -960 {lab=Gdrive}
N 41360 -960 41360 -850 {lab=Gdrive}
N 41190 -790 41190 -700 {lab=Gate[27]}
N 41280 -700 41360 -700 {lab=Gate[27]}
N 41360 -790 41360 -700 {lab=Gate[27]}
N 41500 -790 41500 -650 {lab=Gate[27]}
N 41390 -650 41500 -650 {lab=Gate[27]}
N 41280 -700 41280 -650 {lab=Gate[27]}
N 41190 -700 41280 -700 {lab=Gate[27]}
N 41390 -650 41390 -570 {lab=Gate[27]}
N 41280 -650 41390 -650 {lab=Gate[27]}
N 41440 -820 41460 -820 {lab=ctrl_n[27]}
N 41690 -960 41690 -850 {lab=Ssense}
N 41780 -960 41860 -960 {lab=Ssense}
N 41860 -960 41860 -850 {lab=Ssense}
N 41690 -790 41690 -700 {lab=Source[27]}
N 41780 -700 41860 -700 {lab=Source[27]}
N 41860 -790 41860 -700 {lab=Source[27]}
N 41780 -700 41780 -650 {lab=Source[27]}
N 41690 -700 41780 -700 {lab=Source[27]}
N 42060 -960 42060 -850 {lab=Sforce}
N 42150 -960 42230 -960 {lab=Sforce}
N 42230 -960 42230 -850 {lab=Sforce}
N 42060 -790 42060 -700 {lab=Source[27]}
N 42150 -700 42230 -700 {lab=Source[27]}
N 42230 -790 42230 -700 {lab=Source[27]}
N 42150 -700 42150 -650 {lab=Source[27]}
N 42060 -700 42150 -700 {lab=Source[27]}
N 41960 -650 42150 -650 {lab=Source[27]}
N 42150 -1140 43650 -1140 {lab=Sforce}
N 42150 -1140 42150 -960 {lab=Sforce}
N 42060 -960 42150 -960 {lab=Sforce}
N 41780 -1170 43280 -1170 {lab=Ssense}
N 41780 -1170 41780 -960 {lab=Ssense}
N 41690 -960 41780 -960 {lab=Ssense}
N 41280 -1200 42780 -1200 {lab=Gdrive}
N 41280 -1200 41280 -960 {lab=Gdrive}
N 41190 -960 41280 -960 {lab=Gdrive}
N 41500 -1230 43000 -1230 {lab=Vcl}
N 41500 -1230 41500 -850 {lab=Vcl}
N 41740 -1380 41740 -1350 {lab=ctrl_p[27]}
N 41610 -1350 41740 -1350 {lab=ctrl_p[27]}
N 41110 -1350 41110 -820 {lab=ctrl_p[27]}
N 41110 -820 41150 -820 {lab=ctrl_p[27]}
N 41610 -820 41650 -820 {lab=ctrl_p[27]}
N 41610 -1350 41610 -820 {lab=ctrl_p[27]}
N 41110 -1350 41610 -1350 {lab=ctrl_p[27]}
N 41440 -1320 41440 -820 {lab=ctrl_n[27]}
N 41400 -820 41440 -820 {lab=ctrl_n[27]}
N 41440 -1320 41790 -1320 {lab=ctrl_n[27]}
N 41790 -1380 41790 -1320 {lab=ctrl_n[27]}
N 41900 -820 41940 -820 {lab=ctrl_n[27]}
N 41980 -820 42020 -820 {lab=ctrl_p[27]}
N 41940 -1320 42300 -1320 {lab=ctrl_n[27]}
N 41940 -1320 41940 -820 {lab=ctrl_n[27]}
N 41790 -1320 41940 -1320 {lab=ctrl_n[27]}
N 41740 -1350 41980 -1350 {lab=ctrl_p[27]}
N 41980 -1350 41980 -820 {lab=ctrl_p[27]}
N 42300 -1320 42300 -820 {lab=ctrl_n[27]}
N 42270 -820 42300 -820 {lab=ctrl_n[27]}
N 41960 -650 41960 -580 {lab=Source[27]}
N 41780 -650 41960 -650 {lab=Source[27]}
N 41190 -820 41230 -820 {lab=#net190}
N 41230 -820 41230 -460 {lab=#net190}
N 41500 -820 41540 -820 {lab=#net191}
N 41540 -820 41540 -460 {lab=#net191}
N 41230 -400 41230 -330 {lab=Vss}
N 42100 -330 42400 -330 {lab=Vss}
N 42400 -1080 42400 -330 {lab=Vss}
N 42400 -1080 43900 -1080 {lab=Vss}
N 42370 -1110 43870 -1110 {lab=1.2V}
N 42370 -1110 42370 -360 {lab=1.2V}
N 41540 -400 41540 -330 {lab=Vss}
N 41230 -330 41540 -330 {lab=Vss}
N 42190 -360 42370 -360 {lab=1.2V}
N 41820 -820 41860 -820 {lab=#net192}
N 41820 -820 41820 -460 {lab=#net192}
N 41690 -820 41730 -820 {lab=#net193}
N 41730 -820 41730 -460 {lab=#net193}
N 41820 -400 41820 -360 {lab=1.2V}
N 41730 -400 41730 -330 {lab=Vss}
N 41540 -330 41730 -330 {lab=Vss}
N 41310 -820 41360 -820 {lab=#net194}
N 41310 -820 41310 -460 {lab=#net194}
N 41310 -400 41310 -360 {lab=1.2V}
N 41310 -360 41820 -360 {lab=1.2V}
N 42060 -820 42100 -820 {lab=#net195}
N 42100 -820 42100 -460 {lab=#net195}
N 42190 -820 42230 -820 {lab=#net196}
N 42190 -820 42190 -460 {lab=#net196}
N 42190 -400 42190 -360 {lab=1.2V}
N 41820 -360 42190 -360 {lab=1.2V}
N 42100 -400 42100 -330 {lab=Vss}
N 41730 -330 42100 -330 {lab=Vss}
N 42690 -960 42690 -850 {lab=Gdrive}
N 42780 -960 42860 -960 {lab=Gdrive}
N 42860 -960 42860 -850 {lab=Gdrive}
N 42690 -790 42690 -700 {lab=Gate[28]}
N 42780 -700 42860 -700 {lab=Gate[28]}
N 42860 -790 42860 -700 {lab=Gate[28]}
N 43000 -790 43000 -650 {lab=Gate[28]}
N 42890 -650 43000 -650 {lab=Gate[28]}
N 42780 -700 42780 -650 {lab=Gate[28]}
N 42690 -700 42780 -700 {lab=Gate[28]}
N 42890 -650 42890 -570 {lab=Gate[28]}
N 42780 -650 42890 -650 {lab=Gate[28]}
N 42940 -820 42960 -820 {lab=ctrl_n[28]}
N 43190 -960 43190 -850 {lab=Ssense}
N 43280 -960 43360 -960 {lab=Ssense}
N 43360 -960 43360 -850 {lab=Ssense}
N 43190 -790 43190 -700 {lab=Source[28]}
N 43280 -700 43360 -700 {lab=Source[28]}
N 43360 -790 43360 -700 {lab=Source[28]}
N 43280 -700 43280 -650 {lab=Source[28]}
N 43190 -700 43280 -700 {lab=Source[28]}
N 43560 -960 43560 -850 {lab=Sforce}
N 43650 -960 43730 -960 {lab=Sforce}
N 43730 -960 43730 -850 {lab=Sforce}
N 43560 -790 43560 -700 {lab=Source[28]}
N 43650 -700 43730 -700 {lab=Source[28]}
N 43730 -790 43730 -700 {lab=Source[28]}
N 43650 -700 43650 -650 {lab=Source[28]}
N 43560 -700 43650 -700 {lab=Source[28]}
N 43460 -650 43650 -650 {lab=Source[28]}
N 43650 -1140 45150 -1140 {lab=Sforce}
N 43650 -1140 43650 -960 {lab=Sforce}
N 43560 -960 43650 -960 {lab=Sforce}
N 43280 -1170 44780 -1170 {lab=Ssense}
N 43280 -1170 43280 -960 {lab=Ssense}
N 43190 -960 43280 -960 {lab=Ssense}
N 42780 -1200 44280 -1200 {lab=Gdrive}
N 42780 -1200 42780 -960 {lab=Gdrive}
N 42690 -960 42780 -960 {lab=Gdrive}
N 43000 -1230 44500 -1230 {lab=Vcl}
N 43000 -1230 43000 -850 {lab=Vcl}
N 43240 -1380 43240 -1350 {lab=ctrl_p[28]}
N 43110 -1350 43240 -1350 {lab=ctrl_p[28]}
N 42610 -1350 42610 -820 {lab=ctrl_p[28]}
N 42610 -820 42650 -820 {lab=ctrl_p[28]}
N 43110 -820 43150 -820 {lab=ctrl_p[28]}
N 43110 -1350 43110 -820 {lab=ctrl_p[28]}
N 42610 -1350 43110 -1350 {lab=ctrl_p[28]}
N 42940 -1320 42940 -820 {lab=ctrl_n[28]}
N 42900 -820 42940 -820 {lab=ctrl_n[28]}
N 42940 -1320 43290 -1320 {lab=ctrl_n[28]}
N 43290 -1380 43290 -1320 {lab=ctrl_n[28]}
N 43400 -820 43440 -820 {lab=ctrl_n[28]}
N 43480 -820 43520 -820 {lab=ctrl_p[28]}
N 43440 -1320 43800 -1320 {lab=ctrl_n[28]}
N 43440 -1320 43440 -820 {lab=ctrl_n[28]}
N 43290 -1320 43440 -1320 {lab=ctrl_n[28]}
N 43240 -1350 43480 -1350 {lab=ctrl_p[28]}
N 43480 -1350 43480 -820 {lab=ctrl_p[28]}
N 43800 -1320 43800 -820 {lab=ctrl_n[28]}
N 43770 -820 43800 -820 {lab=ctrl_n[28]}
N 43460 -650 43460 -580 {lab=Source[28]}
N 43280 -650 43460 -650 {lab=Source[28]}
N 42690 -820 42730 -820 {lab=#net197}
N 42730 -820 42730 -460 {lab=#net197}
N 43000 -820 43040 -820 {lab=#net198}
N 43040 -820 43040 -460 {lab=#net198}
N 42730 -400 42730 -330 {lab=Vss}
N 43600 -330 43900 -330 {lab=Vss}
N 43900 -1080 43900 -330 {lab=Vss}
N 43900 -1080 45400 -1080 {lab=Vss}
N 43870 -1110 45370 -1110 {lab=1.2V}
N 43870 -1110 43870 -360 {lab=1.2V}
N 43040 -400 43040 -330 {lab=Vss}
N 42730 -330 43040 -330 {lab=Vss}
N 43690 -360 43870 -360 {lab=1.2V}
N 43320 -820 43360 -820 {lab=#net199}
N 43320 -820 43320 -460 {lab=#net199}
N 43190 -820 43230 -820 {lab=#net200}
N 43230 -820 43230 -460 {lab=#net200}
N 43320 -400 43320 -360 {lab=1.2V}
N 43230 -400 43230 -330 {lab=Vss}
N 43040 -330 43230 -330 {lab=Vss}
N 42810 -820 42860 -820 {lab=#net201}
N 42810 -820 42810 -460 {lab=#net201}
N 42810 -400 42810 -360 {lab=1.2V}
N 42810 -360 43320 -360 {lab=1.2V}
N 43560 -820 43600 -820 {lab=#net202}
N 43600 -820 43600 -460 {lab=#net202}
N 43690 -820 43730 -820 {lab=#net203}
N 43690 -820 43690 -460 {lab=#net203}
N 43690 -400 43690 -360 {lab=1.2V}
N 43320 -360 43690 -360 {lab=1.2V}
N 43600 -400 43600 -330 {lab=Vss}
N 43230 -330 43600 -330 {lab=Vss}
N 44190 -960 44190 -850 {lab=Gdrive}
N 44280 -960 44360 -960 {lab=Gdrive}
N 44360 -960 44360 -850 {lab=Gdrive}
N 44190 -790 44190 -700 {lab=Gate[29]}
N 44280 -700 44360 -700 {lab=Gate[29]}
N 44360 -790 44360 -700 {lab=Gate[29]}
N 44500 -790 44500 -650 {lab=Gate[29]}
N 44390 -650 44500 -650 {lab=Gate[29]}
N 44280 -700 44280 -650 {lab=Gate[29]}
N 44190 -700 44280 -700 {lab=Gate[29]}
N 44390 -650 44390 -570 {lab=Gate[29]}
N 44280 -650 44390 -650 {lab=Gate[29]}
N 44440 -820 44460 -820 {lab=ctrl_n[29]}
N 44690 -960 44690 -850 {lab=Ssense}
N 44780 -960 44860 -960 {lab=Ssense}
N 44860 -960 44860 -850 {lab=Ssense}
N 44690 -790 44690 -700 {lab=Source[29]}
N 44780 -700 44860 -700 {lab=Source[29]}
N 44860 -790 44860 -700 {lab=Source[29]}
N 44780 -700 44780 -650 {lab=Source[29]}
N 44690 -700 44780 -700 {lab=Source[29]}
N 45060 -960 45060 -850 {lab=Sforce}
N 45150 -960 45230 -960 {lab=Sforce}
N 45230 -960 45230 -850 {lab=Sforce}
N 45060 -790 45060 -700 {lab=Source[29]}
N 45150 -700 45230 -700 {lab=Source[29]}
N 45230 -790 45230 -700 {lab=Source[29]}
N 45150 -700 45150 -650 {lab=Source[29]}
N 45060 -700 45150 -700 {lab=Source[29]}
N 44960 -650 45150 -650 {lab=Source[29]}
N 45150 -1140 46650 -1140 {lab=Sforce}
N 45150 -1140 45150 -960 {lab=Sforce}
N 45060 -960 45150 -960 {lab=Sforce}
N 44780 -1170 46280 -1170 {lab=Ssense}
N 44780 -1170 44780 -960 {lab=Ssense}
N 44690 -960 44780 -960 {lab=Ssense}
N 44280 -1200 45780 -1200 {lab=Gdrive}
N 44280 -1200 44280 -960 {lab=Gdrive}
N 44190 -960 44280 -960 {lab=Gdrive}
N 44500 -1230 46000 -1230 {lab=Vcl}
N 44500 -1230 44500 -850 {lab=Vcl}
N 44740 -1380 44740 -1350 {lab=ctrl_p[29]}
N 44610 -1350 44740 -1350 {lab=ctrl_p[29]}
N 44110 -1350 44110 -820 {lab=ctrl_p[29]}
N 44110 -820 44150 -820 {lab=ctrl_p[29]}
N 44610 -820 44650 -820 {lab=ctrl_p[29]}
N 44610 -1350 44610 -820 {lab=ctrl_p[29]}
N 44110 -1350 44610 -1350 {lab=ctrl_p[29]}
N 44440 -1320 44440 -820 {lab=ctrl_n[29]}
N 44400 -820 44440 -820 {lab=ctrl_n[29]}
N 44440 -1320 44790 -1320 {lab=ctrl_n[29]}
N 44790 -1380 44790 -1320 {lab=ctrl_n[29]}
N 44900 -820 44940 -820 {lab=ctrl_n[29]}
N 44980 -820 45020 -820 {lab=ctrl_p[29]}
N 44940 -1320 45300 -1320 {lab=ctrl_n[29]}
N 44940 -1320 44940 -820 {lab=ctrl_n[29]}
N 44790 -1320 44940 -1320 {lab=ctrl_n[29]}
N 44740 -1350 44980 -1350 {lab=ctrl_p[29]}
N 44980 -1350 44980 -820 {lab=ctrl_p[29]}
N 45300 -1320 45300 -820 {lab=ctrl_n[29]}
N 45270 -820 45300 -820 {lab=ctrl_n[29]}
N 44960 -650 44960 -580 {lab=Source[29]}
N 44780 -650 44960 -650 {lab=Source[29]}
N 44190 -820 44230 -820 {lab=#net204}
N 44230 -820 44230 -460 {lab=#net204}
N 44500 -820 44540 -820 {lab=#net205}
N 44540 -820 44540 -460 {lab=#net205}
N 44230 -400 44230 -330 {lab=Vss}
N 45100 -330 45400 -330 {lab=Vss}
N 45400 -1080 45400 -330 {lab=Vss}
N 45400 -1080 46900 -1080 {lab=Vss}
N 45370 -1110 46870 -1110 {lab=1.2V}
N 45370 -1110 45370 -360 {lab=1.2V}
N 44540 -400 44540 -330 {lab=Vss}
N 44230 -330 44540 -330 {lab=Vss}
N 45190 -360 45370 -360 {lab=1.2V}
N 44820 -820 44860 -820 {lab=#net206}
N 44820 -820 44820 -460 {lab=#net206}
N 44690 -820 44730 -820 {lab=#net207}
N 44730 -820 44730 -460 {lab=#net207}
N 44820 -400 44820 -360 {lab=1.2V}
N 44730 -400 44730 -330 {lab=Vss}
N 44540 -330 44730 -330 {lab=Vss}
N 44310 -820 44360 -820 {lab=#net208}
N 44310 -820 44310 -460 {lab=#net208}
N 44310 -400 44310 -360 {lab=1.2V}
N 44310 -360 44820 -360 {lab=1.2V}
N 45060 -820 45100 -820 {lab=#net209}
N 45100 -820 45100 -460 {lab=#net209}
N 45190 -820 45230 -820 {lab=#net210}
N 45190 -820 45190 -460 {lab=#net210}
N 45190 -400 45190 -360 {lab=1.2V}
N 44820 -360 45190 -360 {lab=1.2V}
N 45100 -400 45100 -330 {lab=Vss}
N 44730 -330 45100 -330 {lab=Vss}
N 45690 -960 45690 -850 {lab=Gdrive}
N 45780 -960 45860 -960 {lab=Gdrive}
N 45860 -960 45860 -850 {lab=Gdrive}
N 45690 -790 45690 -700 {lab=Gate[30]}
N 45780 -700 45860 -700 {lab=Gate[30]}
N 45860 -790 45860 -700 {lab=Gate[30]}
N 46000 -790 46000 -650 {lab=Gate[30]}
N 45890 -650 46000 -650 {lab=Gate[30]}
N 45780 -700 45780 -650 {lab=Gate[30]}
N 45690 -700 45780 -700 {lab=Gate[30]}
N 45890 -650 45890 -570 {lab=Gate[30]}
N 45780 -650 45890 -650 {lab=Gate[30]}
N 45940 -820 45960 -820 {lab=ctrl_n[30]}
N 46190 -960 46190 -850 {lab=Ssense}
N 46280 -960 46360 -960 {lab=Ssense}
N 46360 -960 46360 -850 {lab=Ssense}
N 46190 -790 46190 -700 {lab=Source[30]}
N 46280 -700 46360 -700 {lab=Source[30]}
N 46360 -790 46360 -700 {lab=Source[30]}
N 46280 -700 46280 -650 {lab=Source[30]}
N 46190 -700 46280 -700 {lab=Source[30]}
N 46560 -960 46560 -850 {lab=Sforce}
N 46650 -960 46730 -960 {lab=Sforce}
N 46730 -960 46730 -850 {lab=Sforce}
N 46560 -790 46560 -700 {lab=Source[30]}
N 46650 -700 46730 -700 {lab=Source[30]}
N 46730 -790 46730 -700 {lab=Source[30]}
N 46650 -700 46650 -650 {lab=Source[30]}
N 46560 -700 46650 -700 {lab=Source[30]}
N 46460 -650 46650 -650 {lab=Source[30]}
N 46650 -1140 48150 -1140 {lab=Sforce}
N 46650 -1140 46650 -960 {lab=Sforce}
N 46560 -960 46650 -960 {lab=Sforce}
N 46280 -1170 47780 -1170 {lab=Ssense}
N 46280 -1170 46280 -960 {lab=Ssense}
N 46190 -960 46280 -960 {lab=Ssense}
N 45780 -1200 47280 -1200 {lab=Gdrive}
N 45780 -1200 45780 -960 {lab=Gdrive}
N 45690 -960 45780 -960 {lab=Gdrive}
N 46000 -1230 47500 -1230 {lab=Vcl}
N 46000 -1230 46000 -850 {lab=Vcl}
N 46240 -1380 46240 -1350 {lab=ctrl_p[30]}
N 46110 -1350 46240 -1350 {lab=ctrl_p[30]}
N 45610 -1350 45610 -820 {lab=ctrl_p[30]}
N 45610 -820 45650 -820 {lab=ctrl_p[30]}
N 46110 -820 46150 -820 {lab=ctrl_p[30]}
N 46110 -1350 46110 -820 {lab=ctrl_p[30]}
N 45610 -1350 46110 -1350 {lab=ctrl_p[30]}
N 45940 -1320 45940 -820 {lab=ctrl_n[30]}
N 45900 -820 45940 -820 {lab=ctrl_n[30]}
N 45940 -1320 46290 -1320 {lab=ctrl_n[30]}
N 46290 -1380 46290 -1320 {lab=ctrl_n[30]}
N 46400 -820 46440 -820 {lab=ctrl_n[30]}
N 46480 -820 46520 -820 {lab=ctrl_p[30]}
N 46440 -1320 46800 -1320 {lab=ctrl_n[30]}
N 46440 -1320 46440 -820 {lab=ctrl_n[30]}
N 46290 -1320 46440 -1320 {lab=ctrl_n[30]}
N 46240 -1350 46480 -1350 {lab=ctrl_p[30]}
N 46480 -1350 46480 -820 {lab=ctrl_p[30]}
N 46800 -1320 46800 -820 {lab=ctrl_n[30]}
N 46770 -820 46800 -820 {lab=ctrl_n[30]}
N 46460 -650 46460 -580 {lab=Source[30]}
N 46280 -650 46460 -650 {lab=Source[30]}
N 45690 -820 45730 -820 {lab=#net211}
N 45730 -820 45730 -460 {lab=#net211}
N 46000 -820 46040 -820 {lab=#net212}
N 46040 -820 46040 -460 {lab=#net212}
N 45730 -400 45730 -330 {lab=Vss}
N 46600 -330 46900 -330 {lab=Vss}
N 46900 -1080 46900 -330 {lab=Vss}
N 46900 -1080 48400 -1080 {lab=Vss}
N 46870 -1110 48370 -1110 {lab=1.2V}
N 46870 -1110 46870 -360 {lab=1.2V}
N 46040 -400 46040 -330 {lab=Vss}
N 45730 -330 46040 -330 {lab=Vss}
N 46690 -360 46870 -360 {lab=1.2V}
N 46320 -820 46360 -820 {lab=#net213}
N 46320 -820 46320 -460 {lab=#net213}
N 46190 -820 46230 -820 {lab=#net214}
N 46230 -820 46230 -460 {lab=#net214}
N 46320 -400 46320 -360 {lab=1.2V}
N 46230 -400 46230 -330 {lab=Vss}
N 46040 -330 46230 -330 {lab=Vss}
N 45810 -820 45860 -820 {lab=#net215}
N 45810 -820 45810 -460 {lab=#net215}
N 45810 -400 45810 -360 {lab=1.2V}
N 45810 -360 46320 -360 {lab=1.2V}
N 46560 -820 46600 -820 {lab=#net216}
N 46600 -820 46600 -460 {lab=#net216}
N 46690 -820 46730 -820 {lab=#net217}
N 46690 -820 46690 -460 {lab=#net217}
N 46690 -400 46690 -360 {lab=1.2V}
N 46320 -360 46690 -360 {lab=1.2V}
N 46600 -400 46600 -330 {lab=Vss}
N 46230 -330 46600 -330 {lab=Vss}
N 47190 -960 47190 -850 {lab=Gdrive}
N 47280 -960 47360 -960 {lab=Gdrive}
N 47360 -960 47360 -850 {lab=Gdrive}
N 47190 -790 47190 -700 {lab=Gate[31]}
N 47280 -700 47360 -700 {lab=Gate[31]}
N 47360 -790 47360 -700 {lab=Gate[31]}
N 47500 -790 47500 -650 {lab=Gate[31]}
N 47390 -650 47500 -650 {lab=Gate[31]}
N 47280 -700 47280 -650 {lab=Gate[31]}
N 47190 -700 47280 -700 {lab=Gate[31]}
N 47390 -650 47390 -570 {lab=Gate[31]}
N 47280 -650 47390 -650 {lab=Gate[31]}
N 47440 -820 47460 -820 {lab=ctrl_n[31]}
N 47690 -960 47690 -850 {lab=Ssense}
N 47780 -960 47860 -960 {lab=Ssense}
N 47860 -960 47860 -850 {lab=Ssense}
N 47690 -790 47690 -700 {lab=Source[31]}
N 47780 -700 47860 -700 {lab=Source[31]}
N 47860 -790 47860 -700 {lab=Source[31]}
N 47780 -700 47780 -650 {lab=Source[31]}
N 47690 -700 47780 -700 {lab=Source[31]}
N 48060 -960 48060 -850 {lab=Sforce}
N 48150 -960 48230 -960 {lab=Sforce}
N 48230 -960 48230 -850 {lab=Sforce}
N 48060 -790 48060 -700 {lab=Source[31]}
N 48150 -700 48230 -700 {lab=Source[31]}
N 48230 -790 48230 -700 {lab=Source[31]}
N 48150 -700 48150 -650 {lab=Source[31]}
N 48060 -700 48150 -700 {lab=Source[31]}
N 47960 -650 48150 -650 {lab=Source[31]}
N 48150 -1140 49650 -1140 {lab=Sforce}
N 48150 -1140 48150 -960 {lab=Sforce}
N 48060 -960 48150 -960 {lab=Sforce}
N 47780 -1170 49280 -1170 {lab=Ssense}
N 47780 -1170 47780 -960 {lab=Ssense}
N 47690 -960 47780 -960 {lab=Ssense}
N 47280 -1200 48780 -1200 {lab=Gdrive}
N 47280 -1200 47280 -960 {lab=Gdrive}
N 47190 -960 47280 -960 {lab=Gdrive}
N 47500 -1230 49000 -1230 {lab=Vcl}
N 47500 -1230 47500 -850 {lab=Vcl}
N 47740 -1380 47740 -1350 {lab=ctrl_p[31]}
N 47610 -1350 47740 -1350 {lab=ctrl_p[31]}
N 47110 -1350 47110 -820 {lab=ctrl_p[31]}
N 47110 -820 47150 -820 {lab=ctrl_p[31]}
N 47610 -820 47650 -820 {lab=ctrl_p[31]}
N 47610 -1350 47610 -820 {lab=ctrl_p[31]}
N 47110 -1350 47610 -1350 {lab=ctrl_p[31]}
N 47440 -1320 47440 -820 {lab=ctrl_n[31]}
N 47400 -820 47440 -820 {lab=ctrl_n[31]}
N 47440 -1320 47790 -1320 {lab=ctrl_n[31]}
N 47790 -1380 47790 -1320 {lab=ctrl_n[31]}
N 47900 -820 47940 -820 {lab=ctrl_n[31]}
N 47980 -820 48020 -820 {lab=ctrl_p[31]}
N 47940 -1320 48300 -1320 {lab=ctrl_n[31]}
N 47940 -1320 47940 -820 {lab=ctrl_n[31]}
N 47790 -1320 47940 -1320 {lab=ctrl_n[31]}
N 47740 -1350 47980 -1350 {lab=ctrl_p[31]}
N 47980 -1350 47980 -820 {lab=ctrl_p[31]}
N 48300 -1320 48300 -820 {lab=ctrl_n[31]}
N 48270 -820 48300 -820 {lab=ctrl_n[31]}
N 47960 -650 47960 -580 {lab=Source[31]}
N 47780 -650 47960 -650 {lab=Source[31]}
N 47190 -820 47230 -820 {lab=#net218}
N 47230 -820 47230 -460 {lab=#net218}
N 47500 -820 47540 -820 {lab=#net219}
N 47540 -820 47540 -460 {lab=#net219}
N 47230 -400 47230 -330 {lab=Vss}
N 48100 -330 48400 -330 {lab=Vss}
N 48400 -1080 48400 -330 {lab=Vss}
N 48400 -1080 49900 -1080 {lab=Vss}
N 48370 -1110 49870 -1110 {lab=1.2V}
N 48370 -1110 48370 -360 {lab=1.2V}
N 47540 -400 47540 -330 {lab=Vss}
N 47230 -330 47540 -330 {lab=Vss}
N 48190 -360 48370 -360 {lab=1.2V}
N 47820 -820 47860 -820 {lab=#net220}
N 47820 -820 47820 -460 {lab=#net220}
N 47690 -820 47730 -820 {lab=#net221}
N 47730 -820 47730 -460 {lab=#net221}
N 47820 -400 47820 -360 {lab=1.2V}
N 47730 -400 47730 -330 {lab=Vss}
N 47540 -330 47730 -330 {lab=Vss}
N 47310 -820 47360 -820 {lab=#net222}
N 47310 -820 47310 -460 {lab=#net222}
N 47310 -400 47310 -360 {lab=1.2V}
N 47310 -360 47820 -360 {lab=1.2V}
N 48060 -820 48100 -820 {lab=#net223}
N 48100 -820 48100 -460 {lab=#net223}
N 48190 -820 48230 -820 {lab=#net224}
N 48190 -820 48190 -460 {lab=#net224}
N 48190 -400 48190 -360 {lab=1.2V}
N 47820 -360 48190 -360 {lab=1.2V}
N 48100 -400 48100 -330 {lab=Vss}
N 47730 -330 48100 -330 {lab=Vss}
N 48690 -960 48690 -850 {lab=Gdrive}
N 48780 -960 48860 -960 {lab=Gdrive}
N 48860 -960 48860 -850 {lab=Gdrive}
N 48690 -790 48690 -700 {lab=Gate[32]}
N 48780 -700 48860 -700 {lab=Gate[32]}
N 48860 -790 48860 -700 {lab=Gate[32]}
N 49000 -790 49000 -650 {lab=Gate[32]}
N 48890 -650 49000 -650 {lab=Gate[32]}
N 48780 -700 48780 -650 {lab=Gate[32]}
N 48690 -700 48780 -700 {lab=Gate[32]}
N 48890 -650 48890 -570 {lab=Gate[32]}
N 48780 -650 48890 -650 {lab=Gate[32]}
N 48940 -820 48960 -820 {lab=ctrl_n[32]}
N 49190 -960 49190 -850 {lab=Ssense}
N 49280 -960 49360 -960 {lab=Ssense}
N 49360 -960 49360 -850 {lab=Ssense}
N 49190 -790 49190 -700 {lab=Source[32]}
N 49280 -700 49360 -700 {lab=Source[32]}
N 49360 -790 49360 -700 {lab=Source[32]}
N 49280 -700 49280 -650 {lab=Source[32]}
N 49190 -700 49280 -700 {lab=Source[32]}
N 49560 -960 49560 -850 {lab=Sforce}
N 49650 -960 49730 -960 {lab=Sforce}
N 49730 -960 49730 -850 {lab=Sforce}
N 49560 -790 49560 -700 {lab=Source[32]}
N 49650 -700 49730 -700 {lab=Source[32]}
N 49730 -790 49730 -700 {lab=Source[32]}
N 49650 -700 49650 -650 {lab=Source[32]}
N 49560 -700 49650 -700 {lab=Source[32]}
N 49460 -650 49650 -650 {lab=Source[32]}
N 49650 -1140 51150 -1140 {lab=Sforce}
N 49650 -1140 49650 -960 {lab=Sforce}
N 49560 -960 49650 -960 {lab=Sforce}
N 49280 -1170 50780 -1170 {lab=Ssense}
N 49280 -1170 49280 -960 {lab=Ssense}
N 49190 -960 49280 -960 {lab=Ssense}
N 48780 -1200 50280 -1200 {lab=Gdrive}
N 48780 -1200 48780 -960 {lab=Gdrive}
N 48690 -960 48780 -960 {lab=Gdrive}
N 49000 -1230 50500 -1230 {lab=Vcl}
N 49000 -1230 49000 -850 {lab=Vcl}
N 49240 -1380 49240 -1350 {lab=ctrl_p[32]}
N 49110 -1350 49240 -1350 {lab=ctrl_p[32]}
N 48610 -1350 48610 -820 {lab=ctrl_p[32]}
N 48610 -820 48650 -820 {lab=ctrl_p[32]}
N 49110 -820 49150 -820 {lab=ctrl_p[32]}
N 49110 -1350 49110 -820 {lab=ctrl_p[32]}
N 48610 -1350 49110 -1350 {lab=ctrl_p[32]}
N 48940 -1320 48940 -820 {lab=ctrl_n[32]}
N 48900 -820 48940 -820 {lab=ctrl_n[32]}
N 48940 -1320 49290 -1320 {lab=ctrl_n[32]}
N 49290 -1380 49290 -1320 {lab=ctrl_n[32]}
N 49400 -820 49440 -820 {lab=ctrl_n[32]}
N 49480 -820 49520 -820 {lab=ctrl_p[32]}
N 49440 -1320 49800 -1320 {lab=ctrl_n[32]}
N 49440 -1320 49440 -820 {lab=ctrl_n[32]}
N 49290 -1320 49440 -1320 {lab=ctrl_n[32]}
N 49240 -1350 49480 -1350 {lab=ctrl_p[32]}
N 49480 -1350 49480 -820 {lab=ctrl_p[32]}
N 49800 -1320 49800 -820 {lab=ctrl_n[32]}
N 49770 -820 49800 -820 {lab=ctrl_n[32]}
N 49460 -650 49460 -580 {lab=Source[32]}
N 49280 -650 49460 -650 {lab=Source[32]}
N 48690 -820 48730 -820 {lab=#net225}
N 48730 -820 48730 -460 {lab=#net225}
N 49000 -820 49040 -820 {lab=#net226}
N 49040 -820 49040 -460 {lab=#net226}
N 48730 -400 48730 -330 {lab=Vss}
N 49600 -330 49900 -330 {lab=Vss}
N 49900 -1080 49900 -330 {lab=Vss}
N 49900 -1080 51400 -1080 {lab=Vss}
N 49870 -1110 51370 -1110 {lab=1.2V}
N 49870 -1110 49870 -360 {lab=1.2V}
N 49040 -400 49040 -330 {lab=Vss}
N 48730 -330 49040 -330 {lab=Vss}
N 49690 -360 49870 -360 {lab=1.2V}
N 49320 -820 49360 -820 {lab=#net227}
N 49320 -820 49320 -460 {lab=#net227}
N 49190 -820 49230 -820 {lab=#net228}
N 49230 -820 49230 -460 {lab=#net228}
N 49320 -400 49320 -360 {lab=1.2V}
N 49230 -400 49230 -330 {lab=Vss}
N 49040 -330 49230 -330 {lab=Vss}
N 48810 -820 48860 -820 {lab=#net229}
N 48810 -820 48810 -460 {lab=#net229}
N 48810 -400 48810 -360 {lab=1.2V}
N 48810 -360 49320 -360 {lab=1.2V}
N 49560 -820 49600 -820 {lab=#net230}
N 49600 -820 49600 -460 {lab=#net230}
N 49690 -820 49730 -820 {lab=#net231}
N 49690 -820 49690 -460 {lab=#net231}
N 49690 -400 49690 -360 {lab=1.2V}
N 49320 -360 49690 -360 {lab=1.2V}
N 49600 -400 49600 -330 {lab=Vss}
N 49230 -330 49600 -330 {lab=Vss}
N 50190 -960 50190 -850 {lab=Gdrive}
N 50280 -960 50360 -960 {lab=Gdrive}
N 50360 -960 50360 -850 {lab=Gdrive}
N 50190 -790 50190 -700 {lab=Gate[33]}
N 50280 -700 50360 -700 {lab=Gate[33]}
N 50360 -790 50360 -700 {lab=Gate[33]}
N 50500 -790 50500 -650 {lab=Gate[33]}
N 50390 -650 50500 -650 {lab=Gate[33]}
N 50280 -700 50280 -650 {lab=Gate[33]}
N 50190 -700 50280 -700 {lab=Gate[33]}
N 50390 -650 50390 -570 {lab=Gate[33]}
N 50280 -650 50390 -650 {lab=Gate[33]}
N 50440 -820 50460 -820 {lab=ctrl_n[33]}
N 50690 -960 50690 -850 {lab=Ssense}
N 50780 -960 50860 -960 {lab=Ssense}
N 50860 -960 50860 -850 {lab=Ssense}
N 50690 -790 50690 -700 {lab=Source[33]}
N 50780 -700 50860 -700 {lab=Source[33]}
N 50860 -790 50860 -700 {lab=Source[33]}
N 50780 -700 50780 -650 {lab=Source[33]}
N 50690 -700 50780 -700 {lab=Source[33]}
N 51060 -960 51060 -850 {lab=Sforce}
N 51150 -960 51230 -960 {lab=Sforce}
N 51230 -960 51230 -850 {lab=Sforce}
N 51060 -790 51060 -700 {lab=Source[33]}
N 51150 -700 51230 -700 {lab=Source[33]}
N 51230 -790 51230 -700 {lab=Source[33]}
N 51150 -700 51150 -650 {lab=Source[33]}
N 51060 -700 51150 -700 {lab=Source[33]}
N 50960 -650 51150 -650 {lab=Source[33]}
N 51150 -1140 52650 -1140 {lab=Sforce}
N 51150 -1140 51150 -960 {lab=Sforce}
N 51060 -960 51150 -960 {lab=Sforce}
N 50780 -1170 52280 -1170 {lab=Ssense}
N 50780 -1170 50780 -960 {lab=Ssense}
N 50690 -960 50780 -960 {lab=Ssense}
N 50280 -1200 51780 -1200 {lab=Gdrive}
N 50280 -1200 50280 -960 {lab=Gdrive}
N 50190 -960 50280 -960 {lab=Gdrive}
N 50500 -1230 52000 -1230 {lab=Vcl}
N 50500 -1230 50500 -850 {lab=Vcl}
N 50740 -1380 50740 -1350 {lab=ctrl_p[33]}
N 50610 -1350 50740 -1350 {lab=ctrl_p[33]}
N 50110 -1350 50110 -820 {lab=ctrl_p[33]}
N 50110 -820 50150 -820 {lab=ctrl_p[33]}
N 50610 -820 50650 -820 {lab=ctrl_p[33]}
N 50610 -1350 50610 -820 {lab=ctrl_p[33]}
N 50110 -1350 50610 -1350 {lab=ctrl_p[33]}
N 50440 -1320 50440 -820 {lab=ctrl_n[33]}
N 50400 -820 50440 -820 {lab=ctrl_n[33]}
N 50440 -1320 50790 -1320 {lab=ctrl_n[33]}
N 50790 -1380 50790 -1320 {lab=ctrl_n[33]}
N 50900 -820 50940 -820 {lab=ctrl_n[33]}
N 50980 -820 51020 -820 {lab=ctrl_p[33]}
N 50940 -1320 51300 -1320 {lab=ctrl_n[33]}
N 50940 -1320 50940 -820 {lab=ctrl_n[33]}
N 50790 -1320 50940 -1320 {lab=ctrl_n[33]}
N 50740 -1350 50980 -1350 {lab=ctrl_p[33]}
N 50980 -1350 50980 -820 {lab=ctrl_p[33]}
N 51300 -1320 51300 -820 {lab=ctrl_n[33]}
N 51270 -820 51300 -820 {lab=ctrl_n[33]}
N 50960 -650 50960 -580 {lab=Source[33]}
N 50780 -650 50960 -650 {lab=Source[33]}
N 50190 -820 50230 -820 {lab=#net232}
N 50230 -820 50230 -460 {lab=#net232}
N 50500 -820 50540 -820 {lab=#net233}
N 50540 -820 50540 -460 {lab=#net233}
N 50230 -400 50230 -330 {lab=Vss}
N 51100 -330 51400 -330 {lab=Vss}
N 51400 -1080 51400 -330 {lab=Vss}
N 51400 -1080 52900 -1080 {lab=Vss}
N 51370 -1110 52870 -1110 {lab=1.2V}
N 51370 -1110 51370 -360 {lab=1.2V}
N 50540 -400 50540 -330 {lab=Vss}
N 50230 -330 50540 -330 {lab=Vss}
N 51190 -360 51370 -360 {lab=1.2V}
N 50820 -820 50860 -820 {lab=#net234}
N 50820 -820 50820 -460 {lab=#net234}
N 50690 -820 50730 -820 {lab=#net235}
N 50730 -820 50730 -460 {lab=#net235}
N 50820 -400 50820 -360 {lab=1.2V}
N 50730 -400 50730 -330 {lab=Vss}
N 50540 -330 50730 -330 {lab=Vss}
N 50310 -820 50360 -820 {lab=#net236}
N 50310 -820 50310 -460 {lab=#net236}
N 50310 -400 50310 -360 {lab=1.2V}
N 50310 -360 50820 -360 {lab=1.2V}
N 51060 -820 51100 -820 {lab=#net237}
N 51100 -820 51100 -460 {lab=#net237}
N 51190 -820 51230 -820 {lab=#net238}
N 51190 -820 51190 -460 {lab=#net238}
N 51190 -400 51190 -360 {lab=1.2V}
N 50820 -360 51190 -360 {lab=1.2V}
N 51100 -400 51100 -330 {lab=Vss}
N 50730 -330 51100 -330 {lab=Vss}
N 51690 -960 51690 -850 {lab=Gdrive}
N 51780 -960 51860 -960 {lab=Gdrive}
N 51860 -960 51860 -850 {lab=Gdrive}
N 51690 -790 51690 -700 {lab=Gate[34]}
N 51780 -700 51860 -700 {lab=Gate[34]}
N 51860 -790 51860 -700 {lab=Gate[34]}
N 52000 -790 52000 -650 {lab=Gate[34]}
N 51890 -650 52000 -650 {lab=Gate[34]}
N 51780 -700 51780 -650 {lab=Gate[34]}
N 51690 -700 51780 -700 {lab=Gate[34]}
N 51890 -650 51890 -570 {lab=Gate[34]}
N 51780 -650 51890 -650 {lab=Gate[34]}
N 51940 -820 51960 -820 {lab=ctrl_n[34]}
N 52190 -960 52190 -850 {lab=Ssense}
N 52280 -960 52360 -960 {lab=Ssense}
N 52360 -960 52360 -850 {lab=Ssense}
N 52190 -790 52190 -700 {lab=Source[34]}
N 52280 -700 52360 -700 {lab=Source[34]}
N 52360 -790 52360 -700 {lab=Source[34]}
N 52280 -700 52280 -650 {lab=Source[34]}
N 52190 -700 52280 -700 {lab=Source[34]}
N 52560 -960 52560 -850 {lab=Sforce}
N 52650 -960 52730 -960 {lab=Sforce}
N 52730 -960 52730 -850 {lab=Sforce}
N 52560 -790 52560 -700 {lab=Source[34]}
N 52650 -700 52730 -700 {lab=Source[34]}
N 52730 -790 52730 -700 {lab=Source[34]}
N 52650 -700 52650 -650 {lab=Source[34]}
N 52560 -700 52650 -700 {lab=Source[34]}
N 52460 -650 52650 -650 {lab=Source[34]}
N 52650 -1140 54150 -1140 {lab=Sforce}
N 52650 -1140 52650 -960 {lab=Sforce}
N 52560 -960 52650 -960 {lab=Sforce}
N 52280 -1170 53780 -1170 {lab=Ssense}
N 52280 -1170 52280 -960 {lab=Ssense}
N 52190 -960 52280 -960 {lab=Ssense}
N 51780 -1200 53280 -1200 {lab=Gdrive}
N 51780 -1200 51780 -960 {lab=Gdrive}
N 51690 -960 51780 -960 {lab=Gdrive}
N 52000 -1230 53500 -1230 {lab=Vcl}
N 52000 -1230 52000 -850 {lab=Vcl}
N 52240 -1380 52240 -1350 {lab=ctrl_p[34]}
N 52110 -1350 52240 -1350 {lab=ctrl_p[34]}
N 51610 -1350 51610 -820 {lab=ctrl_p[34]}
N 51610 -820 51650 -820 {lab=ctrl_p[34]}
N 52110 -820 52150 -820 {lab=ctrl_p[34]}
N 52110 -1350 52110 -820 {lab=ctrl_p[34]}
N 51610 -1350 52110 -1350 {lab=ctrl_p[34]}
N 51940 -1320 51940 -820 {lab=ctrl_n[34]}
N 51900 -820 51940 -820 {lab=ctrl_n[34]}
N 51940 -1320 52290 -1320 {lab=ctrl_n[34]}
N 52290 -1380 52290 -1320 {lab=ctrl_n[34]}
N 52400 -820 52440 -820 {lab=ctrl_n[34]}
N 52480 -820 52520 -820 {lab=ctrl_p[34]}
N 52440 -1320 52800 -1320 {lab=ctrl_n[34]}
N 52440 -1320 52440 -820 {lab=ctrl_n[34]}
N 52290 -1320 52440 -1320 {lab=ctrl_n[34]}
N 52240 -1350 52480 -1350 {lab=ctrl_p[34]}
N 52480 -1350 52480 -820 {lab=ctrl_p[34]}
N 52800 -1320 52800 -820 {lab=ctrl_n[34]}
N 52770 -820 52800 -820 {lab=ctrl_n[34]}
N 52460 -650 52460 -580 {lab=Source[34]}
N 52280 -650 52460 -650 {lab=Source[34]}
N 51690 -820 51730 -820 {lab=#net239}
N 51730 -820 51730 -460 {lab=#net239}
N 52000 -820 52040 -820 {lab=#net240}
N 52040 -820 52040 -460 {lab=#net240}
N 51730 -400 51730 -330 {lab=Vss}
N 52600 -330 52900 -330 {lab=Vss}
N 52900 -1080 52900 -330 {lab=Vss}
N 52900 -1080 54400 -1080 {lab=Vss}
N 52870 -1110 54370 -1110 {lab=1.2V}
N 52870 -1110 52870 -360 {lab=1.2V}
N 52040 -400 52040 -330 {lab=Vss}
N 51730 -330 52040 -330 {lab=Vss}
N 52690 -360 52870 -360 {lab=1.2V}
N 52320 -820 52360 -820 {lab=#net241}
N 52320 -820 52320 -460 {lab=#net241}
N 52190 -820 52230 -820 {lab=#net242}
N 52230 -820 52230 -460 {lab=#net242}
N 52320 -400 52320 -360 {lab=1.2V}
N 52230 -400 52230 -330 {lab=Vss}
N 52040 -330 52230 -330 {lab=Vss}
N 51810 -820 51860 -820 {lab=#net243}
N 51810 -820 51810 -460 {lab=#net243}
N 51810 -400 51810 -360 {lab=1.2V}
N 51810 -360 52320 -360 {lab=1.2V}
N 52560 -820 52600 -820 {lab=#net244}
N 52600 -820 52600 -460 {lab=#net244}
N 52690 -820 52730 -820 {lab=#net245}
N 52690 -820 52690 -460 {lab=#net245}
N 52690 -400 52690 -360 {lab=1.2V}
N 52320 -360 52690 -360 {lab=1.2V}
N 52600 -400 52600 -330 {lab=Vss}
N 52230 -330 52600 -330 {lab=Vss}
N 53190 -960 53190 -850 {lab=Gdrive}
N 53280 -960 53360 -960 {lab=Gdrive}
N 53360 -960 53360 -850 {lab=Gdrive}
N 53190 -790 53190 -700 {lab=Gate[35]}
N 53280 -700 53360 -700 {lab=Gate[35]}
N 53360 -790 53360 -700 {lab=Gate[35]}
N 53500 -790 53500 -650 {lab=Gate[35]}
N 53390 -650 53500 -650 {lab=Gate[35]}
N 53280 -700 53280 -650 {lab=Gate[35]}
N 53190 -700 53280 -700 {lab=Gate[35]}
N 53390 -650 53390 -570 {lab=Gate[35]}
N 53280 -650 53390 -650 {lab=Gate[35]}
N 53440 -820 53460 -820 {lab=ctrl_n[35]}
N 53690 -960 53690 -850 {lab=Ssense}
N 53780 -960 53860 -960 {lab=Ssense}
N 53860 -960 53860 -850 {lab=Ssense}
N 53690 -790 53690 -700 {lab=Source[35]}
N 53780 -700 53860 -700 {lab=Source[35]}
N 53860 -790 53860 -700 {lab=Source[35]}
N 53780 -700 53780 -650 {lab=Source[35]}
N 53690 -700 53780 -700 {lab=Source[35]}
N 54060 -960 54060 -850 {lab=Sforce}
N 54150 -960 54230 -960 {lab=Sforce}
N 54230 -960 54230 -850 {lab=Sforce}
N 54060 -790 54060 -700 {lab=Source[35]}
N 54150 -700 54230 -700 {lab=Source[35]}
N 54230 -790 54230 -700 {lab=Source[35]}
N 54150 -700 54150 -650 {lab=Source[35]}
N 54060 -700 54150 -700 {lab=Source[35]}
N 53960 -650 54150 -650 {lab=Source[35]}
N 54150 -1140 55650 -1140 {lab=Sforce}
N 54150 -1140 54150 -960 {lab=Sforce}
N 54060 -960 54150 -960 {lab=Sforce}
N 53780 -1170 55280 -1170 {lab=Ssense}
N 53780 -1170 53780 -960 {lab=Ssense}
N 53690 -960 53780 -960 {lab=Ssense}
N 53280 -1200 54780 -1200 {lab=Gdrive}
N 53280 -1200 53280 -960 {lab=Gdrive}
N 53190 -960 53280 -960 {lab=Gdrive}
N 53500 -1230 55000 -1230 {lab=Vcl}
N 53500 -1230 53500 -850 {lab=Vcl}
N 53740 -1380 53740 -1350 {lab=ctrl_p[35]}
N 53610 -1350 53740 -1350 {lab=ctrl_p[35]}
N 53110 -1350 53110 -820 {lab=ctrl_p[35]}
N 53110 -820 53150 -820 {lab=ctrl_p[35]}
N 53610 -820 53650 -820 {lab=ctrl_p[35]}
N 53610 -1350 53610 -820 {lab=ctrl_p[35]}
N 53110 -1350 53610 -1350 {lab=ctrl_p[35]}
N 53440 -1320 53440 -820 {lab=ctrl_n[35]}
N 53400 -820 53440 -820 {lab=ctrl_n[35]}
N 53440 -1320 53790 -1320 {lab=ctrl_n[35]}
N 53790 -1380 53790 -1320 {lab=ctrl_n[35]}
N 53900 -820 53940 -820 {lab=ctrl_n[35]}
N 53980 -820 54020 -820 {lab=ctrl_p[35]}
N 53940 -1320 54300 -1320 {lab=ctrl_n[35]}
N 53940 -1320 53940 -820 {lab=ctrl_n[35]}
N 53790 -1320 53940 -1320 {lab=ctrl_n[35]}
N 53740 -1350 53980 -1350 {lab=ctrl_p[35]}
N 53980 -1350 53980 -820 {lab=ctrl_p[35]}
N 54300 -1320 54300 -820 {lab=ctrl_n[35]}
N 54270 -820 54300 -820 {lab=ctrl_n[35]}
N 53960 -650 53960 -580 {lab=Source[35]}
N 53780 -650 53960 -650 {lab=Source[35]}
N 53190 -820 53230 -820 {lab=#net246}
N 53230 -820 53230 -460 {lab=#net246}
N 53500 -820 53540 -820 {lab=#net247}
N 53540 -820 53540 -460 {lab=#net247}
N 53230 -400 53230 -330 {lab=Vss}
N 54100 -330 54400 -330 {lab=Vss}
N 54400 -1080 54400 -330 {lab=Vss}
N 54400 -1080 55900 -1080 {lab=Vss}
N 54370 -1110 55870 -1110 {lab=1.2V}
N 54370 -1110 54370 -360 {lab=1.2V}
N 53540 -400 53540 -330 {lab=Vss}
N 53230 -330 53540 -330 {lab=Vss}
N 54190 -360 54370 -360 {lab=1.2V}
N 53820 -820 53860 -820 {lab=#net248}
N 53820 -820 53820 -460 {lab=#net248}
N 53690 -820 53730 -820 {lab=#net249}
N 53730 -820 53730 -460 {lab=#net249}
N 53820 -400 53820 -360 {lab=1.2V}
N 53730 -400 53730 -330 {lab=Vss}
N 53540 -330 53730 -330 {lab=Vss}
N 53310 -820 53360 -820 {lab=#net250}
N 53310 -820 53310 -460 {lab=#net250}
N 53310 -400 53310 -360 {lab=1.2V}
N 53310 -360 53820 -360 {lab=1.2V}
N 54060 -820 54100 -820 {lab=#net251}
N 54100 -820 54100 -460 {lab=#net251}
N 54190 -820 54230 -820 {lab=#net252}
N 54190 -820 54190 -460 {lab=#net252}
N 54190 -400 54190 -360 {lab=1.2V}
N 53820 -360 54190 -360 {lab=1.2V}
N 54100 -400 54100 -330 {lab=Vss}
N 53730 -330 54100 -330 {lab=Vss}
N 54690 -960 54690 -850 {lab=Gdrive}
N 54780 -960 54860 -960 {lab=Gdrive}
N 54860 -960 54860 -850 {lab=Gdrive}
N 54690 -790 54690 -700 {lab=Gate[36]}
N 54780 -700 54860 -700 {lab=Gate[36]}
N 54860 -790 54860 -700 {lab=Gate[36]}
N 55000 -790 55000 -650 {lab=Gate[36]}
N 54890 -650 55000 -650 {lab=Gate[36]}
N 54780 -700 54780 -650 {lab=Gate[36]}
N 54690 -700 54780 -700 {lab=Gate[36]}
N 54890 -650 54890 -570 {lab=Gate[36]}
N 54780 -650 54890 -650 {lab=Gate[36]}
N 54940 -820 54960 -820 {lab=ctrl_n[36]}
N 55190 -960 55190 -850 {lab=Ssense}
N 55280 -960 55360 -960 {lab=Ssense}
N 55360 -960 55360 -850 {lab=Ssense}
N 55190 -790 55190 -700 {lab=Source[36]}
N 55280 -700 55360 -700 {lab=Source[36]}
N 55360 -790 55360 -700 {lab=Source[36]}
N 55280 -700 55280 -650 {lab=Source[36]}
N 55190 -700 55280 -700 {lab=Source[36]}
N 55560 -960 55560 -850 {lab=Sforce}
N 55650 -960 55730 -960 {lab=Sforce}
N 55730 -960 55730 -850 {lab=Sforce}
N 55560 -790 55560 -700 {lab=Source[36]}
N 55650 -700 55730 -700 {lab=Source[36]}
N 55730 -790 55730 -700 {lab=Source[36]}
N 55650 -700 55650 -650 {lab=Source[36]}
N 55560 -700 55650 -700 {lab=Source[36]}
N 55460 -650 55650 -650 {lab=Source[36]}
N 55650 -1140 57150 -1140 {lab=Sforce}
N 55650 -1140 55650 -960 {lab=Sforce}
N 55560 -960 55650 -960 {lab=Sforce}
N 55280 -1170 56780 -1170 {lab=Ssense}
N 55280 -1170 55280 -960 {lab=Ssense}
N 55190 -960 55280 -960 {lab=Ssense}
N 54780 -1200 56280 -1200 {lab=Gdrive}
N 54780 -1200 54780 -960 {lab=Gdrive}
N 54690 -960 54780 -960 {lab=Gdrive}
N 55000 -1230 56500 -1230 {lab=Vcl}
N 55000 -1230 55000 -850 {lab=Vcl}
N 55240 -1380 55240 -1350 {lab=ctrl_p[36]}
N 55110 -1350 55240 -1350 {lab=ctrl_p[36]}
N 54610 -1350 54610 -820 {lab=ctrl_p[36]}
N 54610 -820 54650 -820 {lab=ctrl_p[36]}
N 55110 -820 55150 -820 {lab=ctrl_p[36]}
N 55110 -1350 55110 -820 {lab=ctrl_p[36]}
N 54610 -1350 55110 -1350 {lab=ctrl_p[36]}
N 54940 -1320 54940 -820 {lab=ctrl_n[36]}
N 54900 -820 54940 -820 {lab=ctrl_n[36]}
N 54940 -1320 55290 -1320 {lab=ctrl_n[36]}
N 55290 -1380 55290 -1320 {lab=ctrl_n[36]}
N 55400 -820 55440 -820 {lab=ctrl_n[36]}
N 55480 -820 55520 -820 {lab=ctrl_p[36]}
N 55440 -1320 55800 -1320 {lab=ctrl_n[36]}
N 55440 -1320 55440 -820 {lab=ctrl_n[36]}
N 55290 -1320 55440 -1320 {lab=ctrl_n[36]}
N 55240 -1350 55480 -1350 {lab=ctrl_p[36]}
N 55480 -1350 55480 -820 {lab=ctrl_p[36]}
N 55800 -1320 55800 -820 {lab=ctrl_n[36]}
N 55770 -820 55800 -820 {lab=ctrl_n[36]}
N 55460 -650 55460 -580 {lab=Source[36]}
N 55280 -650 55460 -650 {lab=Source[36]}
N 54690 -820 54730 -820 {lab=#net253}
N 54730 -820 54730 -460 {lab=#net253}
N 55000 -820 55040 -820 {lab=#net254}
N 55040 -820 55040 -460 {lab=#net254}
N 54730 -400 54730 -330 {lab=Vss}
N 55600 -330 55900 -330 {lab=Vss}
N 55900 -1080 55900 -330 {lab=Vss}
N 55900 -1080 57400 -1080 {lab=Vss}
N 55870 -1110 57370 -1110 {lab=1.2V}
N 55870 -1110 55870 -360 {lab=1.2V}
N 55040 -400 55040 -330 {lab=Vss}
N 54730 -330 55040 -330 {lab=Vss}
N 55690 -360 55870 -360 {lab=1.2V}
N 55320 -820 55360 -820 {lab=#net255}
N 55320 -820 55320 -460 {lab=#net255}
N 55190 -820 55230 -820 {lab=#net256}
N 55230 -820 55230 -460 {lab=#net256}
N 55320 -400 55320 -360 {lab=1.2V}
N 55230 -400 55230 -330 {lab=Vss}
N 55040 -330 55230 -330 {lab=Vss}
N 54810 -820 54860 -820 {lab=#net257}
N 54810 -820 54810 -460 {lab=#net257}
N 54810 -400 54810 -360 {lab=1.2V}
N 54810 -360 55320 -360 {lab=1.2V}
N 55560 -820 55600 -820 {lab=#net258}
N 55600 -820 55600 -460 {lab=#net258}
N 55690 -820 55730 -820 {lab=#net259}
N 55690 -820 55690 -460 {lab=#net259}
N 55690 -400 55690 -360 {lab=1.2V}
N 55320 -360 55690 -360 {lab=1.2V}
N 55600 -400 55600 -330 {lab=Vss}
N 55230 -330 55600 -330 {lab=Vss}
N 56190 -960 56190 -850 {lab=Gdrive}
N 56280 -960 56360 -960 {lab=Gdrive}
N 56360 -960 56360 -850 {lab=Gdrive}
N 56190 -790 56190 -700 {lab=Gate[37]}
N 56280 -700 56360 -700 {lab=Gate[37]}
N 56360 -790 56360 -700 {lab=Gate[37]}
N 56500 -790 56500 -650 {lab=Gate[37]}
N 56390 -650 56500 -650 {lab=Gate[37]}
N 56280 -700 56280 -650 {lab=Gate[37]}
N 56190 -700 56280 -700 {lab=Gate[37]}
N 56390 -650 56390 -570 {lab=Gate[37]}
N 56280 -650 56390 -650 {lab=Gate[37]}
N 56440 -820 56460 -820 {lab=ctrl_n[37]}
N 56690 -960 56690 -850 {lab=Ssense}
N 56780 -960 56860 -960 {lab=Ssense}
N 56860 -960 56860 -850 {lab=Ssense}
N 56690 -790 56690 -700 {lab=Source[37]}
N 56780 -700 56860 -700 {lab=Source[37]}
N 56860 -790 56860 -700 {lab=Source[37]}
N 56780 -700 56780 -650 {lab=Source[37]}
N 56690 -700 56780 -700 {lab=Source[37]}
N 57060 -960 57060 -850 {lab=Sforce}
N 57150 -960 57230 -960 {lab=Sforce}
N 57230 -960 57230 -850 {lab=Sforce}
N 57060 -790 57060 -700 {lab=Source[37]}
N 57150 -700 57230 -700 {lab=Source[37]}
N 57230 -790 57230 -700 {lab=Source[37]}
N 57150 -700 57150 -650 {lab=Source[37]}
N 57060 -700 57150 -700 {lab=Source[37]}
N 56960 -650 57150 -650 {lab=Source[37]}
N 57150 -1140 58650 -1140 {lab=Sforce}
N 57150 -1140 57150 -960 {lab=Sforce}
N 57060 -960 57150 -960 {lab=Sforce}
N 56780 -1170 58280 -1170 {lab=Ssense}
N 56780 -1170 56780 -960 {lab=Ssense}
N 56690 -960 56780 -960 {lab=Ssense}
N 56280 -1200 57780 -1200 {lab=Gdrive}
N 56280 -1200 56280 -960 {lab=Gdrive}
N 56190 -960 56280 -960 {lab=Gdrive}
N 56500 -1230 58000 -1230 {lab=Vcl}
N 56500 -1230 56500 -850 {lab=Vcl}
N 56740 -1380 56740 -1350 {lab=ctrl_p[37]}
N 56610 -1350 56740 -1350 {lab=ctrl_p[37]}
N 56110 -1350 56110 -820 {lab=ctrl_p[37]}
N 56110 -820 56150 -820 {lab=ctrl_p[37]}
N 56610 -820 56650 -820 {lab=ctrl_p[37]}
N 56610 -1350 56610 -820 {lab=ctrl_p[37]}
N 56110 -1350 56610 -1350 {lab=ctrl_p[37]}
N 56440 -1320 56440 -820 {lab=ctrl_n[37]}
N 56400 -820 56440 -820 {lab=ctrl_n[37]}
N 56440 -1320 56790 -1320 {lab=ctrl_n[37]}
N 56790 -1380 56790 -1320 {lab=ctrl_n[37]}
N 56900 -820 56940 -820 {lab=ctrl_n[37]}
N 56980 -820 57020 -820 {lab=ctrl_p[37]}
N 56940 -1320 57300 -1320 {lab=ctrl_n[37]}
N 56940 -1320 56940 -820 {lab=ctrl_n[37]}
N 56790 -1320 56940 -1320 {lab=ctrl_n[37]}
N 56740 -1350 56980 -1350 {lab=ctrl_p[37]}
N 56980 -1350 56980 -820 {lab=ctrl_p[37]}
N 57300 -1320 57300 -820 {lab=ctrl_n[37]}
N 57270 -820 57300 -820 {lab=ctrl_n[37]}
N 56960 -650 56960 -580 {lab=Source[37]}
N 56780 -650 56960 -650 {lab=Source[37]}
N 56190 -820 56230 -820 {lab=#net260}
N 56230 -820 56230 -460 {lab=#net260}
N 56500 -820 56540 -820 {lab=#net261}
N 56540 -820 56540 -460 {lab=#net261}
N 56230 -400 56230 -330 {lab=Vss}
N 57100 -330 57400 -330 {lab=Vss}
N 57400 -1080 57400 -330 {lab=Vss}
N 57400 -1080 58900 -1080 {lab=Vss}
N 57370 -1110 58870 -1110 {lab=1.2V}
N 57370 -1110 57370 -360 {lab=1.2V}
N 56540 -400 56540 -330 {lab=Vss}
N 56230 -330 56540 -330 {lab=Vss}
N 57190 -360 57370 -360 {lab=1.2V}
N 56820 -820 56860 -820 {lab=#net262}
N 56820 -820 56820 -460 {lab=#net262}
N 56690 -820 56730 -820 {lab=#net263}
N 56730 -820 56730 -460 {lab=#net263}
N 56820 -400 56820 -360 {lab=1.2V}
N 56730 -400 56730 -330 {lab=Vss}
N 56540 -330 56730 -330 {lab=Vss}
N 56310 -820 56360 -820 {lab=#net264}
N 56310 -820 56310 -460 {lab=#net264}
N 56310 -400 56310 -360 {lab=1.2V}
N 56310 -360 56820 -360 {lab=1.2V}
N 57060 -820 57100 -820 {lab=#net265}
N 57100 -820 57100 -460 {lab=#net265}
N 57190 -820 57230 -820 {lab=#net266}
N 57190 -820 57190 -460 {lab=#net266}
N 57190 -400 57190 -360 {lab=1.2V}
N 56820 -360 57190 -360 {lab=1.2V}
N 57100 -400 57100 -330 {lab=Vss}
N 56730 -330 57100 -330 {lab=Vss}
N 57690 -960 57690 -850 {lab=Gdrive}
N 57780 -960 57860 -960 {lab=Gdrive}
N 57860 -960 57860 -850 {lab=Gdrive}
N 57690 -790 57690 -700 {lab=Gate[38]}
N 57780 -700 57860 -700 {lab=Gate[38]}
N 57860 -790 57860 -700 {lab=Gate[38]}
N 58000 -790 58000 -650 {lab=Gate[38]}
N 57890 -650 58000 -650 {lab=Gate[38]}
N 57780 -700 57780 -650 {lab=Gate[38]}
N 57690 -700 57780 -700 {lab=Gate[38]}
N 57890 -650 57890 -570 {lab=Gate[38]}
N 57780 -650 57890 -650 {lab=Gate[38]}
N 57940 -820 57960 -820 {lab=ctrl_n[38]}
N 58190 -960 58190 -850 {lab=Ssense}
N 58280 -960 58360 -960 {lab=Ssense}
N 58360 -960 58360 -850 {lab=Ssense}
N 58190 -790 58190 -700 {lab=Source[38]}
N 58280 -700 58360 -700 {lab=Source[38]}
N 58360 -790 58360 -700 {lab=Source[38]}
N 58280 -700 58280 -650 {lab=Source[38]}
N 58190 -700 58280 -700 {lab=Source[38]}
N 58560 -960 58560 -850 {lab=Sforce}
N 58650 -960 58730 -960 {lab=Sforce}
N 58730 -960 58730 -850 {lab=Sforce}
N 58560 -790 58560 -700 {lab=Source[38]}
N 58650 -700 58730 -700 {lab=Source[38]}
N 58730 -790 58730 -700 {lab=Source[38]}
N 58650 -700 58650 -650 {lab=Source[38]}
N 58560 -700 58650 -700 {lab=Source[38]}
N 58460 -650 58650 -650 {lab=Source[38]}
N 58650 -1140 60150 -1140 {lab=Sforce}
N 58650 -1140 58650 -960 {lab=Sforce}
N 58560 -960 58650 -960 {lab=Sforce}
N 58280 -1170 59780 -1170 {lab=Ssense}
N 58280 -1170 58280 -960 {lab=Ssense}
N 58190 -960 58280 -960 {lab=Ssense}
N 57780 -1200 59280 -1200 {lab=Gdrive}
N 57780 -1200 57780 -960 {lab=Gdrive}
N 57690 -960 57780 -960 {lab=Gdrive}
N 58000 -1230 59500 -1230 {lab=Vcl}
N 58000 -1230 58000 -850 {lab=Vcl}
N 58240 -1380 58240 -1350 {lab=ctrl_p[38]}
N 58110 -1350 58240 -1350 {lab=ctrl_p[38]}
N 57610 -1350 57610 -820 {lab=ctrl_p[38]}
N 57610 -820 57650 -820 {lab=ctrl_p[38]}
N 58110 -820 58150 -820 {lab=ctrl_p[38]}
N 58110 -1350 58110 -820 {lab=ctrl_p[38]}
N 57610 -1350 58110 -1350 {lab=ctrl_p[38]}
N 57940 -1320 57940 -820 {lab=ctrl_n[38]}
N 57900 -820 57940 -820 {lab=ctrl_n[38]}
N 57940 -1320 58290 -1320 {lab=ctrl_n[38]}
N 58290 -1380 58290 -1320 {lab=ctrl_n[38]}
N 58400 -820 58440 -820 {lab=ctrl_n[38]}
N 58480 -820 58520 -820 {lab=ctrl_p[38]}
N 58440 -1320 58800 -1320 {lab=ctrl_n[38]}
N 58440 -1320 58440 -820 {lab=ctrl_n[38]}
N 58290 -1320 58440 -1320 {lab=ctrl_n[38]}
N 58240 -1350 58480 -1350 {lab=ctrl_p[38]}
N 58480 -1350 58480 -820 {lab=ctrl_p[38]}
N 58800 -1320 58800 -820 {lab=ctrl_n[38]}
N 58770 -820 58800 -820 {lab=ctrl_n[38]}
N 58460 -650 58460 -580 {lab=Source[38]}
N 58280 -650 58460 -650 {lab=Source[38]}
N 57690 -820 57730 -820 {lab=#net267}
N 57730 -820 57730 -460 {lab=#net267}
N 58000 -820 58040 -820 {lab=#net268}
N 58040 -820 58040 -460 {lab=#net268}
N 57730 -400 57730 -330 {lab=Vss}
N 58600 -330 58900 -330 {lab=Vss}
N 58900 -1080 58900 -330 {lab=Vss}
N 58900 -1080 60400 -1080 {lab=Vss}
N 58870 -1110 60370 -1110 {lab=1.2V}
N 58870 -1110 58870 -360 {lab=1.2V}
N 58040 -400 58040 -330 {lab=Vss}
N 57730 -330 58040 -330 {lab=Vss}
N 58690 -360 58870 -360 {lab=1.2V}
N 58320 -820 58360 -820 {lab=#net269}
N 58320 -820 58320 -460 {lab=#net269}
N 58190 -820 58230 -820 {lab=#net270}
N 58230 -820 58230 -460 {lab=#net270}
N 58320 -400 58320 -360 {lab=1.2V}
N 58230 -400 58230 -330 {lab=Vss}
N 58040 -330 58230 -330 {lab=Vss}
N 57810 -820 57860 -820 {lab=#net271}
N 57810 -820 57810 -460 {lab=#net271}
N 57810 -400 57810 -360 {lab=1.2V}
N 57810 -360 58320 -360 {lab=1.2V}
N 58560 -820 58600 -820 {lab=#net272}
N 58600 -820 58600 -460 {lab=#net272}
N 58690 -820 58730 -820 {lab=#net273}
N 58690 -820 58690 -460 {lab=#net273}
N 58690 -400 58690 -360 {lab=1.2V}
N 58320 -360 58690 -360 {lab=1.2V}
N 58600 -400 58600 -330 {lab=Vss}
N 58230 -330 58600 -330 {lab=Vss}
N 59190 -960 59190 -850 {lab=Gdrive}
N 59280 -960 59360 -960 {lab=Gdrive}
N 59360 -960 59360 -850 {lab=Gdrive}
N 59190 -790 59190 -700 {lab=Gate[39]}
N 59280 -700 59360 -700 {lab=Gate[39]}
N 59360 -790 59360 -700 {lab=Gate[39]}
N 59500 -790 59500 -650 {lab=Gate[39]}
N 59390 -650 59500 -650 {lab=Gate[39]}
N 59280 -700 59280 -650 {lab=Gate[39]}
N 59190 -700 59280 -700 {lab=Gate[39]}
N 59390 -650 59390 -570 {lab=Gate[39]}
N 59280 -650 59390 -650 {lab=Gate[39]}
N 59440 -820 59460 -820 {lab=ctrl_n[39]}
N 59690 -960 59690 -850 {lab=Ssense}
N 59780 -960 59860 -960 {lab=Ssense}
N 59860 -960 59860 -850 {lab=Ssense}
N 59690 -790 59690 -700 {lab=Source[39]}
N 59780 -700 59860 -700 {lab=Source[39]}
N 59860 -790 59860 -700 {lab=Source[39]}
N 59780 -700 59780 -650 {lab=Source[39]}
N 59690 -700 59780 -700 {lab=Source[39]}
N 60060 -960 60060 -850 {lab=Sforce}
N 60150 -960 60230 -960 {lab=Sforce}
N 60230 -960 60230 -850 {lab=Sforce}
N 60060 -790 60060 -700 {lab=Source[39]}
N 60150 -700 60230 -700 {lab=Source[39]}
N 60230 -790 60230 -700 {lab=Source[39]}
N 60150 -700 60150 -650 {lab=Source[39]}
N 60060 -700 60150 -700 {lab=Source[39]}
N 59960 -650 60150 -650 {lab=Source[39]}
N 60150 -1140 61650 -1140 {lab=Sforce}
N 60150 -1140 60150 -960 {lab=Sforce}
N 60060 -960 60150 -960 {lab=Sforce}
N 59780 -1170 61280 -1170 {lab=Ssense}
N 59780 -1170 59780 -960 {lab=Ssense}
N 59690 -960 59780 -960 {lab=Ssense}
N 59280 -1200 60780 -1200 {lab=Gdrive}
N 59280 -1200 59280 -960 {lab=Gdrive}
N 59190 -960 59280 -960 {lab=Gdrive}
N 59500 -1230 61000 -1230 {lab=Vcl}
N 59500 -1230 59500 -850 {lab=Vcl}
N 59740 -1380 59740 -1350 {lab=ctrl_p[39]}
N 59610 -1350 59740 -1350 {lab=ctrl_p[39]}
N 59110 -1350 59110 -820 {lab=ctrl_p[39]}
N 59110 -820 59150 -820 {lab=ctrl_p[39]}
N 59610 -820 59650 -820 {lab=ctrl_p[39]}
N 59610 -1350 59610 -820 {lab=ctrl_p[39]}
N 59110 -1350 59610 -1350 {lab=ctrl_p[39]}
N 59440 -1320 59440 -820 {lab=ctrl_n[39]}
N 59400 -820 59440 -820 {lab=ctrl_n[39]}
N 59440 -1320 59790 -1320 {lab=ctrl_n[39]}
N 59790 -1380 59790 -1320 {lab=ctrl_n[39]}
N 59900 -820 59940 -820 {lab=ctrl_n[39]}
N 59980 -820 60020 -820 {lab=ctrl_p[39]}
N 59940 -1320 60300 -1320 {lab=ctrl_n[39]}
N 59940 -1320 59940 -820 {lab=ctrl_n[39]}
N 59790 -1320 59940 -1320 {lab=ctrl_n[39]}
N 59740 -1350 59980 -1350 {lab=ctrl_p[39]}
N 59980 -1350 59980 -820 {lab=ctrl_p[39]}
N 60300 -1320 60300 -820 {lab=ctrl_n[39]}
N 60270 -820 60300 -820 {lab=ctrl_n[39]}
N 59960 -650 59960 -580 {lab=Source[39]}
N 59780 -650 59960 -650 {lab=Source[39]}
N 59190 -820 59230 -820 {lab=#net274}
N 59230 -820 59230 -460 {lab=#net274}
N 59500 -820 59540 -820 {lab=#net275}
N 59540 -820 59540 -460 {lab=#net275}
N 59230 -400 59230 -330 {lab=Vss}
N 60100 -330 60400 -330 {lab=Vss}
N 60400 -1080 60400 -330 {lab=Vss}
N 60400 -1080 61900 -1080 {lab=Vss}
N 60370 -1110 61870 -1110 {lab=1.2V}
N 60370 -1110 60370 -360 {lab=1.2V}
N 59540 -400 59540 -330 {lab=Vss}
N 59230 -330 59540 -330 {lab=Vss}
N 60190 -360 60370 -360 {lab=1.2V}
N 59820 -820 59860 -820 {lab=#net276}
N 59820 -820 59820 -460 {lab=#net276}
N 59690 -820 59730 -820 {lab=#net277}
N 59730 -820 59730 -460 {lab=#net277}
N 59820 -400 59820 -360 {lab=1.2V}
N 59730 -400 59730 -330 {lab=Vss}
N 59540 -330 59730 -330 {lab=Vss}
N 59310 -820 59360 -820 {lab=#net278}
N 59310 -820 59310 -460 {lab=#net278}
N 59310 -400 59310 -360 {lab=1.2V}
N 59310 -360 59820 -360 {lab=1.2V}
N 60060 -820 60100 -820 {lab=#net279}
N 60100 -820 60100 -460 {lab=#net279}
N 60190 -820 60230 -820 {lab=#net280}
N 60190 -820 60190 -460 {lab=#net280}
N 60190 -400 60190 -360 {lab=1.2V}
N 59820 -360 60190 -360 {lab=1.2V}
N 60100 -400 60100 -330 {lab=Vss}
N 59730 -330 60100 -330 {lab=Vss}
N 60690 -960 60690 -850 {lab=Gdrive}
N 60780 -960 60860 -960 {lab=Gdrive}
N 60860 -960 60860 -850 {lab=Gdrive}
N 60690 -790 60690 -700 {lab=Gate[40]}
N 60780 -700 60860 -700 {lab=Gate[40]}
N 60860 -790 60860 -700 {lab=Gate[40]}
N 61000 -790 61000 -650 {lab=Gate[40]}
N 60890 -650 61000 -650 {lab=Gate[40]}
N 60780 -700 60780 -650 {lab=Gate[40]}
N 60690 -700 60780 -700 {lab=Gate[40]}
N 60890 -650 60890 -570 {lab=Gate[40]}
N 60780 -650 60890 -650 {lab=Gate[40]}
N 60940 -820 60960 -820 {lab=ctrl_n[40]}
N 61190 -960 61190 -850 {lab=Ssense}
N 61280 -960 61360 -960 {lab=Ssense}
N 61360 -960 61360 -850 {lab=Ssense}
N 61190 -790 61190 -700 {lab=Source[40]}
N 61280 -700 61360 -700 {lab=Source[40]}
N 61360 -790 61360 -700 {lab=Source[40]}
N 61280 -700 61280 -650 {lab=Source[40]}
N 61190 -700 61280 -700 {lab=Source[40]}
N 61560 -960 61560 -850 {lab=Sforce}
N 61650 -960 61730 -960 {lab=Sforce}
N 61730 -960 61730 -850 {lab=Sforce}
N 61560 -790 61560 -700 {lab=Source[40]}
N 61650 -700 61730 -700 {lab=Source[40]}
N 61730 -790 61730 -700 {lab=Source[40]}
N 61650 -700 61650 -650 {lab=Source[40]}
N 61560 -700 61650 -700 {lab=Source[40]}
N 61460 -650 61650 -650 {lab=Source[40]}
N 61650 -1140 63150 -1140 {lab=Sforce}
N 61650 -1140 61650 -960 {lab=Sforce}
N 61560 -960 61650 -960 {lab=Sforce}
N 61280 -1170 62780 -1170 {lab=Ssense}
N 61280 -1170 61280 -960 {lab=Ssense}
N 61190 -960 61280 -960 {lab=Ssense}
N 60780 -1200 62280 -1200 {lab=Gdrive}
N 60780 -1200 60780 -960 {lab=Gdrive}
N 60690 -960 60780 -960 {lab=Gdrive}
N 61000 -1230 62500 -1230 {lab=Vcl}
N 61000 -1230 61000 -850 {lab=Vcl}
N 61240 -1380 61240 -1350 {lab=ctrl_p[40]}
N 61110 -1350 61240 -1350 {lab=ctrl_p[40]}
N 60610 -1350 60610 -820 {lab=ctrl_p[40]}
N 60610 -820 60650 -820 {lab=ctrl_p[40]}
N 61110 -820 61150 -820 {lab=ctrl_p[40]}
N 61110 -1350 61110 -820 {lab=ctrl_p[40]}
N 60610 -1350 61110 -1350 {lab=ctrl_p[40]}
N 60940 -1320 60940 -820 {lab=ctrl_n[40]}
N 60900 -820 60940 -820 {lab=ctrl_n[40]}
N 60940 -1320 61290 -1320 {lab=ctrl_n[40]}
N 61290 -1380 61290 -1320 {lab=ctrl_n[40]}
N 61400 -820 61440 -820 {lab=ctrl_n[40]}
N 61480 -820 61520 -820 {lab=ctrl_p[40]}
N 61440 -1320 61800 -1320 {lab=ctrl_n[40]}
N 61440 -1320 61440 -820 {lab=ctrl_n[40]}
N 61290 -1320 61440 -1320 {lab=ctrl_n[40]}
N 61240 -1350 61480 -1350 {lab=ctrl_p[40]}
N 61480 -1350 61480 -820 {lab=ctrl_p[40]}
N 61800 -1320 61800 -820 {lab=ctrl_n[40]}
N 61770 -820 61800 -820 {lab=ctrl_n[40]}
N 61460 -650 61460 -580 {lab=Source[40]}
N 61280 -650 61460 -650 {lab=Source[40]}
N 60690 -820 60730 -820 {lab=#net281}
N 60730 -820 60730 -460 {lab=#net281}
N 61000 -820 61040 -820 {lab=#net282}
N 61040 -820 61040 -460 {lab=#net282}
N 60730 -400 60730 -330 {lab=Vss}
N 61600 -330 61900 -330 {lab=Vss}
N 61900 -1080 61900 -330 {lab=Vss}
N 61900 -1080 63400 -1080 {lab=Vss}
N 61870 -1110 63370 -1110 {lab=1.2V}
N 61870 -1110 61870 -360 {lab=1.2V}
N 61040 -400 61040 -330 {lab=Vss}
N 60730 -330 61040 -330 {lab=Vss}
N 61690 -360 61870 -360 {lab=1.2V}
N 61320 -820 61360 -820 {lab=#net283}
N 61320 -820 61320 -460 {lab=#net283}
N 61190 -820 61230 -820 {lab=#net284}
N 61230 -820 61230 -460 {lab=#net284}
N 61320 -400 61320 -360 {lab=1.2V}
N 61230 -400 61230 -330 {lab=Vss}
N 61040 -330 61230 -330 {lab=Vss}
N 60810 -820 60860 -820 {lab=#net285}
N 60810 -820 60810 -460 {lab=#net285}
N 60810 -400 60810 -360 {lab=1.2V}
N 60810 -360 61320 -360 {lab=1.2V}
N 61560 -820 61600 -820 {lab=#net286}
N 61600 -820 61600 -460 {lab=#net286}
N 61690 -820 61730 -820 {lab=#net287}
N 61690 -820 61690 -460 {lab=#net287}
N 61690 -400 61690 -360 {lab=1.2V}
N 61320 -360 61690 -360 {lab=1.2V}
N 61600 -400 61600 -330 {lab=Vss}
N 61230 -330 61600 -330 {lab=Vss}
N 62190 -960 62190 -850 {lab=Gdrive}
N 62280 -960 62360 -960 {lab=Gdrive}
N 62360 -960 62360 -850 {lab=Gdrive}
N 62190 -790 62190 -700 {lab=Gate[41]}
N 62280 -700 62360 -700 {lab=Gate[41]}
N 62360 -790 62360 -700 {lab=Gate[41]}
N 62500 -790 62500 -650 {lab=Gate[41]}
N 62390 -650 62500 -650 {lab=Gate[41]}
N 62280 -700 62280 -650 {lab=Gate[41]}
N 62190 -700 62280 -700 {lab=Gate[41]}
N 62390 -650 62390 -570 {lab=Gate[41]}
N 62280 -650 62390 -650 {lab=Gate[41]}
N 62440 -820 62460 -820 {lab=ctrl_n[41]}
N 62690 -960 62690 -850 {lab=Ssense}
N 62780 -960 62860 -960 {lab=Ssense}
N 62860 -960 62860 -850 {lab=Ssense}
N 62690 -790 62690 -700 {lab=Source[41]}
N 62780 -700 62860 -700 {lab=Source[41]}
N 62860 -790 62860 -700 {lab=Source[41]}
N 62780 -700 62780 -650 {lab=Source[41]}
N 62690 -700 62780 -700 {lab=Source[41]}
N 63060 -960 63060 -850 {lab=Sforce}
N 63150 -960 63230 -960 {lab=Sforce}
N 63230 -960 63230 -850 {lab=Sforce}
N 63060 -790 63060 -700 {lab=Source[41]}
N 63150 -700 63230 -700 {lab=Source[41]}
N 63230 -790 63230 -700 {lab=Source[41]}
N 63150 -700 63150 -650 {lab=Source[41]}
N 63060 -700 63150 -700 {lab=Source[41]}
N 62960 -650 63150 -650 {lab=Source[41]}
N 63150 -1140 64650 -1140 {lab=Sforce}
N 63150 -1140 63150 -960 {lab=Sforce}
N 63060 -960 63150 -960 {lab=Sforce}
N 62780 -1170 64280 -1170 {lab=Ssense}
N 62780 -1170 62780 -960 {lab=Ssense}
N 62690 -960 62780 -960 {lab=Ssense}
N 62280 -1200 63780 -1200 {lab=Gdrive}
N 62280 -1200 62280 -960 {lab=Gdrive}
N 62190 -960 62280 -960 {lab=Gdrive}
N 62500 -1230 64000 -1230 {lab=Vcl}
N 62500 -1230 62500 -850 {lab=Vcl}
N 62740 -1380 62740 -1350 {lab=ctrl_p[41]}
N 62610 -1350 62740 -1350 {lab=ctrl_p[41]}
N 62110 -1350 62110 -820 {lab=ctrl_p[41]}
N 62110 -820 62150 -820 {lab=ctrl_p[41]}
N 62610 -820 62650 -820 {lab=ctrl_p[41]}
N 62610 -1350 62610 -820 {lab=ctrl_p[41]}
N 62110 -1350 62610 -1350 {lab=ctrl_p[41]}
N 62440 -1320 62440 -820 {lab=ctrl_n[41]}
N 62400 -820 62440 -820 {lab=ctrl_n[41]}
N 62440 -1320 62790 -1320 {lab=ctrl_n[41]}
N 62790 -1380 62790 -1320 {lab=ctrl_n[41]}
N 62900 -820 62940 -820 {lab=ctrl_n[41]}
N 62980 -820 63020 -820 {lab=ctrl_p[41]}
N 62940 -1320 63300 -1320 {lab=ctrl_n[41]}
N 62940 -1320 62940 -820 {lab=ctrl_n[41]}
N 62790 -1320 62940 -1320 {lab=ctrl_n[41]}
N 62740 -1350 62980 -1350 {lab=ctrl_p[41]}
N 62980 -1350 62980 -820 {lab=ctrl_p[41]}
N 63300 -1320 63300 -820 {lab=ctrl_n[41]}
N 63270 -820 63300 -820 {lab=ctrl_n[41]}
N 62960 -650 62960 -580 {lab=Source[41]}
N 62780 -650 62960 -650 {lab=Source[41]}
N 62190 -820 62230 -820 {lab=#net288}
N 62230 -820 62230 -460 {lab=#net288}
N 62500 -820 62540 -820 {lab=#net289}
N 62540 -820 62540 -460 {lab=#net289}
N 62230 -400 62230 -330 {lab=Vss}
N 63100 -330 63400 -330 {lab=Vss}
N 63400 -1080 63400 -330 {lab=Vss}
N 63400 -1080 64900 -1080 {lab=Vss}
N 63370 -1110 64870 -1110 {lab=1.2V}
N 63370 -1110 63370 -360 {lab=1.2V}
N 62540 -400 62540 -330 {lab=Vss}
N 62230 -330 62540 -330 {lab=Vss}
N 63190 -360 63370 -360 {lab=1.2V}
N 62820 -820 62860 -820 {lab=#net290}
N 62820 -820 62820 -460 {lab=#net290}
N 62690 -820 62730 -820 {lab=#net291}
N 62730 -820 62730 -460 {lab=#net291}
N 62820 -400 62820 -360 {lab=1.2V}
N 62730 -400 62730 -330 {lab=Vss}
N 62540 -330 62730 -330 {lab=Vss}
N 62310 -820 62360 -820 {lab=#net292}
N 62310 -820 62310 -460 {lab=#net292}
N 62310 -400 62310 -360 {lab=1.2V}
N 62310 -360 62820 -360 {lab=1.2V}
N 63060 -820 63100 -820 {lab=#net293}
N 63100 -820 63100 -460 {lab=#net293}
N 63190 -820 63230 -820 {lab=#net294}
N 63190 -820 63190 -460 {lab=#net294}
N 63190 -400 63190 -360 {lab=1.2V}
N 62820 -360 63190 -360 {lab=1.2V}
N 63100 -400 63100 -330 {lab=Vss}
N 62730 -330 63100 -330 {lab=Vss}
N 63690 -960 63690 -850 {lab=Gdrive}
N 63780 -960 63860 -960 {lab=Gdrive}
N 63860 -960 63860 -850 {lab=Gdrive}
N 63690 -790 63690 -700 {lab=Gate[42]}
N 63780 -700 63860 -700 {lab=Gate[42]}
N 63860 -790 63860 -700 {lab=Gate[42]}
N 64000 -790 64000 -650 {lab=Gate[42]}
N 63890 -650 64000 -650 {lab=Gate[42]}
N 63780 -700 63780 -650 {lab=Gate[42]}
N 63690 -700 63780 -700 {lab=Gate[42]}
N 63890 -650 63890 -570 {lab=Gate[42]}
N 63780 -650 63890 -650 {lab=Gate[42]}
N 63940 -820 63960 -820 {lab=ctrl_n[42]}
N 64190 -960 64190 -850 {lab=Ssense}
N 64280 -960 64360 -960 {lab=Ssense}
N 64360 -960 64360 -850 {lab=Ssense}
N 64190 -790 64190 -700 {lab=Source[42]}
N 64280 -700 64360 -700 {lab=Source[42]}
N 64360 -790 64360 -700 {lab=Source[42]}
N 64280 -700 64280 -650 {lab=Source[42]}
N 64190 -700 64280 -700 {lab=Source[42]}
N 64560 -960 64560 -850 {lab=Sforce}
N 64650 -960 64730 -960 {lab=Sforce}
N 64730 -960 64730 -850 {lab=Sforce}
N 64560 -790 64560 -700 {lab=Source[42]}
N 64650 -700 64730 -700 {lab=Source[42]}
N 64730 -790 64730 -700 {lab=Source[42]}
N 64650 -700 64650 -650 {lab=Source[42]}
N 64560 -700 64650 -700 {lab=Source[42]}
N 64460 -650 64650 -650 {lab=Source[42]}
N 64650 -1140 66150 -1140 {lab=Sforce}
N 64650 -1140 64650 -960 {lab=Sforce}
N 64560 -960 64650 -960 {lab=Sforce}
N 64280 -1170 65780 -1170 {lab=Ssense}
N 64280 -1170 64280 -960 {lab=Ssense}
N 64190 -960 64280 -960 {lab=Ssense}
N 63780 -1200 65280 -1200 {lab=Gdrive}
N 63780 -1200 63780 -960 {lab=Gdrive}
N 63690 -960 63780 -960 {lab=Gdrive}
N 64000 -1230 65500 -1230 {lab=Vcl}
N 64000 -1230 64000 -850 {lab=Vcl}
N 64240 -1380 64240 -1350 {lab=ctrl_p[42]}
N 64110 -1350 64240 -1350 {lab=ctrl_p[42]}
N 63610 -1350 63610 -820 {lab=ctrl_p[42]}
N 63610 -820 63650 -820 {lab=ctrl_p[42]}
N 64110 -820 64150 -820 {lab=ctrl_p[42]}
N 64110 -1350 64110 -820 {lab=ctrl_p[42]}
N 63610 -1350 64110 -1350 {lab=ctrl_p[42]}
N 63940 -1320 63940 -820 {lab=ctrl_n[42]}
N 63900 -820 63940 -820 {lab=ctrl_n[42]}
N 63940 -1320 64290 -1320 {lab=ctrl_n[42]}
N 64290 -1380 64290 -1320 {lab=ctrl_n[42]}
N 64400 -820 64440 -820 {lab=ctrl_n[42]}
N 64480 -820 64520 -820 {lab=ctrl_p[42]}
N 64440 -1320 64800 -1320 {lab=ctrl_n[42]}
N 64440 -1320 64440 -820 {lab=ctrl_n[42]}
N 64290 -1320 64440 -1320 {lab=ctrl_n[42]}
N 64240 -1350 64480 -1350 {lab=ctrl_p[42]}
N 64480 -1350 64480 -820 {lab=ctrl_p[42]}
N 64800 -1320 64800 -820 {lab=ctrl_n[42]}
N 64770 -820 64800 -820 {lab=ctrl_n[42]}
N 64460 -650 64460 -580 {lab=Source[42]}
N 64280 -650 64460 -650 {lab=Source[42]}
N 63690 -820 63730 -820 {lab=#net295}
N 63730 -820 63730 -460 {lab=#net295}
N 64000 -820 64040 -820 {lab=#net296}
N 64040 -820 64040 -460 {lab=#net296}
N 63730 -400 63730 -330 {lab=Vss}
N 64600 -330 64900 -330 {lab=Vss}
N 64900 -1080 64900 -330 {lab=Vss}
N 64900 -1080 66400 -1080 {lab=Vss}
N 64870 -1110 66370 -1110 {lab=1.2V}
N 64870 -1110 64870 -360 {lab=1.2V}
N 64040 -400 64040 -330 {lab=Vss}
N 63730 -330 64040 -330 {lab=Vss}
N 64690 -360 64870 -360 {lab=1.2V}
N 64320 -820 64360 -820 {lab=#net297}
N 64320 -820 64320 -460 {lab=#net297}
N 64190 -820 64230 -820 {lab=#net298}
N 64230 -820 64230 -460 {lab=#net298}
N 64320 -400 64320 -360 {lab=1.2V}
N 64230 -400 64230 -330 {lab=Vss}
N 64040 -330 64230 -330 {lab=Vss}
N 63810 -820 63860 -820 {lab=#net299}
N 63810 -820 63810 -460 {lab=#net299}
N 63810 -400 63810 -360 {lab=1.2V}
N 63810 -360 64320 -360 {lab=1.2V}
N 64560 -820 64600 -820 {lab=#net300}
N 64600 -820 64600 -460 {lab=#net300}
N 64690 -820 64730 -820 {lab=#net301}
N 64690 -820 64690 -460 {lab=#net301}
N 64690 -400 64690 -360 {lab=1.2V}
N 64320 -360 64690 -360 {lab=1.2V}
N 64600 -400 64600 -330 {lab=Vss}
N 64230 -330 64600 -330 {lab=Vss}
N 65190 -960 65190 -850 {lab=Gdrive}
N 65280 -960 65360 -960 {lab=Gdrive}
N 65360 -960 65360 -850 {lab=Gdrive}
N 65190 -790 65190 -700 {lab=Gate[43]}
N 65280 -700 65360 -700 {lab=Gate[43]}
N 65360 -790 65360 -700 {lab=Gate[43]}
N 65500 -790 65500 -650 {lab=Gate[43]}
N 65390 -650 65500 -650 {lab=Gate[43]}
N 65280 -700 65280 -650 {lab=Gate[43]}
N 65190 -700 65280 -700 {lab=Gate[43]}
N 65390 -650 65390 -570 {lab=Gate[43]}
N 65280 -650 65390 -650 {lab=Gate[43]}
N 65440 -820 65460 -820 {lab=ctrl_n[43]}
N 65690 -960 65690 -850 {lab=Ssense}
N 65780 -960 65860 -960 {lab=Ssense}
N 65860 -960 65860 -850 {lab=Ssense}
N 65690 -790 65690 -700 {lab=Source[43]}
N 65780 -700 65860 -700 {lab=Source[43]}
N 65860 -790 65860 -700 {lab=Source[43]}
N 65780 -700 65780 -650 {lab=Source[43]}
N 65690 -700 65780 -700 {lab=Source[43]}
N 66060 -960 66060 -850 {lab=Sforce}
N 66150 -960 66230 -960 {lab=Sforce}
N 66230 -960 66230 -850 {lab=Sforce}
N 66060 -790 66060 -700 {lab=Source[43]}
N 66150 -700 66230 -700 {lab=Source[43]}
N 66230 -790 66230 -700 {lab=Source[43]}
N 66150 -700 66150 -650 {lab=Source[43]}
N 66060 -700 66150 -700 {lab=Source[43]}
N 65960 -650 66150 -650 {lab=Source[43]}
N 66150 -1140 67650 -1140 {lab=Sforce}
N 66150 -1140 66150 -960 {lab=Sforce}
N 66060 -960 66150 -960 {lab=Sforce}
N 65780 -1170 67280 -1170 {lab=Ssense}
N 65780 -1170 65780 -960 {lab=Ssense}
N 65690 -960 65780 -960 {lab=Ssense}
N 65280 -1200 66780 -1200 {lab=Gdrive}
N 65280 -1200 65280 -960 {lab=Gdrive}
N 65190 -960 65280 -960 {lab=Gdrive}
N 65500 -1230 67000 -1230 {lab=Vcl}
N 65500 -1230 65500 -850 {lab=Vcl}
N 65740 -1380 65740 -1350 {lab=ctrl_p[43]}
N 65610 -1350 65740 -1350 {lab=ctrl_p[43]}
N 65110 -1350 65110 -820 {lab=ctrl_p[43]}
N 65110 -820 65150 -820 {lab=ctrl_p[43]}
N 65610 -820 65650 -820 {lab=ctrl_p[43]}
N 65610 -1350 65610 -820 {lab=ctrl_p[43]}
N 65110 -1350 65610 -1350 {lab=ctrl_p[43]}
N 65440 -1320 65440 -820 {lab=ctrl_n[43]}
N 65400 -820 65440 -820 {lab=ctrl_n[43]}
N 65440 -1320 65790 -1320 {lab=ctrl_n[43]}
N 65790 -1380 65790 -1320 {lab=ctrl_n[43]}
N 65900 -820 65940 -820 {lab=ctrl_n[43]}
N 65980 -820 66020 -820 {lab=ctrl_p[43]}
N 65940 -1320 66300 -1320 {lab=ctrl_n[43]}
N 65940 -1320 65940 -820 {lab=ctrl_n[43]}
N 65790 -1320 65940 -1320 {lab=ctrl_n[43]}
N 65740 -1350 65980 -1350 {lab=ctrl_p[43]}
N 65980 -1350 65980 -820 {lab=ctrl_p[43]}
N 66300 -1320 66300 -820 {lab=ctrl_n[43]}
N 66270 -820 66300 -820 {lab=ctrl_n[43]}
N 65960 -650 65960 -580 {lab=Source[43]}
N 65780 -650 65960 -650 {lab=Source[43]}
N 65190 -820 65230 -820 {lab=#net302}
N 65230 -820 65230 -460 {lab=#net302}
N 65500 -820 65540 -820 {lab=#net303}
N 65540 -820 65540 -460 {lab=#net303}
N 65230 -400 65230 -330 {lab=Vss}
N 66100 -330 66400 -330 {lab=Vss}
N 66400 -1080 66400 -330 {lab=Vss}
N 66400 -1080 67900 -1080 {lab=Vss}
N 66370 -1110 67870 -1110 {lab=1.2V}
N 66370 -1110 66370 -360 {lab=1.2V}
N 65540 -400 65540 -330 {lab=Vss}
N 65230 -330 65540 -330 {lab=Vss}
N 66190 -360 66370 -360 {lab=1.2V}
N 65820 -820 65860 -820 {lab=#net304}
N 65820 -820 65820 -460 {lab=#net304}
N 65690 -820 65730 -820 {lab=#net305}
N 65730 -820 65730 -460 {lab=#net305}
N 65820 -400 65820 -360 {lab=1.2V}
N 65730 -400 65730 -330 {lab=Vss}
N 65540 -330 65730 -330 {lab=Vss}
N 65310 -820 65360 -820 {lab=#net306}
N 65310 -820 65310 -460 {lab=#net306}
N 65310 -400 65310 -360 {lab=1.2V}
N 65310 -360 65820 -360 {lab=1.2V}
N 66060 -820 66100 -820 {lab=#net307}
N 66100 -820 66100 -460 {lab=#net307}
N 66190 -820 66230 -820 {lab=#net308}
N 66190 -820 66190 -460 {lab=#net308}
N 66190 -400 66190 -360 {lab=1.2V}
N 65820 -360 66190 -360 {lab=1.2V}
N 66100 -400 66100 -330 {lab=Vss}
N 65730 -330 66100 -330 {lab=Vss}
N 66690 -960 66690 -850 {lab=Gdrive}
N 66780 -960 66860 -960 {lab=Gdrive}
N 66860 -960 66860 -850 {lab=Gdrive}
N 66690 -790 66690 -700 {lab=Gate[44]}
N 66780 -700 66860 -700 {lab=Gate[44]}
N 66860 -790 66860 -700 {lab=Gate[44]}
N 67000 -790 67000 -650 {lab=Gate[44]}
N 66890 -650 67000 -650 {lab=Gate[44]}
N 66780 -700 66780 -650 {lab=Gate[44]}
N 66690 -700 66780 -700 {lab=Gate[44]}
N 66890 -650 66890 -570 {lab=Gate[44]}
N 66780 -650 66890 -650 {lab=Gate[44]}
N 66940 -820 66960 -820 {lab=ctrl_n[44]}
N 67190 -960 67190 -850 {lab=Ssense}
N 67280 -960 67360 -960 {lab=Ssense}
N 67360 -960 67360 -850 {lab=Ssense}
N 67190 -790 67190 -700 {lab=Source[44]}
N 67280 -700 67360 -700 {lab=Source[44]}
N 67360 -790 67360 -700 {lab=Source[44]}
N 67280 -700 67280 -650 {lab=Source[44]}
N 67190 -700 67280 -700 {lab=Source[44]}
N 67560 -960 67560 -850 {lab=Sforce}
N 67650 -960 67730 -960 {lab=Sforce}
N 67730 -960 67730 -850 {lab=Sforce}
N 67560 -790 67560 -700 {lab=Source[44]}
N 67650 -700 67730 -700 {lab=Source[44]}
N 67730 -790 67730 -700 {lab=Source[44]}
N 67650 -700 67650 -650 {lab=Source[44]}
N 67560 -700 67650 -700 {lab=Source[44]}
N 67460 -650 67650 -650 {lab=Source[44]}
N 67650 -1140 69150 -1140 {lab=Sforce}
N 67650 -1140 67650 -960 {lab=Sforce}
N 67560 -960 67650 -960 {lab=Sforce}
N 67280 -1170 68780 -1170 {lab=Ssense}
N 67280 -1170 67280 -960 {lab=Ssense}
N 67190 -960 67280 -960 {lab=Ssense}
N 66780 -1200 68280 -1200 {lab=Gdrive}
N 66780 -1200 66780 -960 {lab=Gdrive}
N 66690 -960 66780 -960 {lab=Gdrive}
N 67000 -1230 68500 -1230 {lab=Vcl}
N 67000 -1230 67000 -850 {lab=Vcl}
N 67240 -1380 67240 -1350 {lab=ctrl_p[44]}
N 67110 -1350 67240 -1350 {lab=ctrl_p[44]}
N 66610 -1350 66610 -820 {lab=ctrl_p[44]}
N 66610 -820 66650 -820 {lab=ctrl_p[44]}
N 67110 -820 67150 -820 {lab=ctrl_p[44]}
N 67110 -1350 67110 -820 {lab=ctrl_p[44]}
N 66610 -1350 67110 -1350 {lab=ctrl_p[44]}
N 66940 -1320 66940 -820 {lab=ctrl_n[44]}
N 66900 -820 66940 -820 {lab=ctrl_n[44]}
N 66940 -1320 67290 -1320 {lab=ctrl_n[44]}
N 67290 -1380 67290 -1320 {lab=ctrl_n[44]}
N 67400 -820 67440 -820 {lab=ctrl_n[44]}
N 67480 -820 67520 -820 {lab=ctrl_p[44]}
N 67440 -1320 67800 -1320 {lab=ctrl_n[44]}
N 67440 -1320 67440 -820 {lab=ctrl_n[44]}
N 67290 -1320 67440 -1320 {lab=ctrl_n[44]}
N 67240 -1350 67480 -1350 {lab=ctrl_p[44]}
N 67480 -1350 67480 -820 {lab=ctrl_p[44]}
N 67800 -1320 67800 -820 {lab=ctrl_n[44]}
N 67770 -820 67800 -820 {lab=ctrl_n[44]}
N 67460 -650 67460 -580 {lab=Source[44]}
N 67280 -650 67460 -650 {lab=Source[44]}
N 66690 -820 66730 -820 {lab=#net309}
N 66730 -820 66730 -460 {lab=#net309}
N 67000 -820 67040 -820 {lab=#net310}
N 67040 -820 67040 -460 {lab=#net310}
N 66730 -400 66730 -330 {lab=Vss}
N 67600 -330 67900 -330 {lab=Vss}
N 67900 -1080 67900 -330 {lab=Vss}
N 67900 -1080 69400 -1080 {lab=Vss}
N 67870 -1110 69370 -1110 {lab=1.2V}
N 67870 -1110 67870 -360 {lab=1.2V}
N 67040 -400 67040 -330 {lab=Vss}
N 66730 -330 67040 -330 {lab=Vss}
N 67690 -360 67870 -360 {lab=1.2V}
N 67320 -820 67360 -820 {lab=#net311}
N 67320 -820 67320 -460 {lab=#net311}
N 67190 -820 67230 -820 {lab=#net312}
N 67230 -820 67230 -460 {lab=#net312}
N 67320 -400 67320 -360 {lab=1.2V}
N 67230 -400 67230 -330 {lab=Vss}
N 67040 -330 67230 -330 {lab=Vss}
N 66810 -820 66860 -820 {lab=#net313}
N 66810 -820 66810 -460 {lab=#net313}
N 66810 -400 66810 -360 {lab=1.2V}
N 66810 -360 67320 -360 {lab=1.2V}
N 67560 -820 67600 -820 {lab=#net314}
N 67600 -820 67600 -460 {lab=#net314}
N 67690 -820 67730 -820 {lab=#net315}
N 67690 -820 67690 -460 {lab=#net315}
N 67690 -400 67690 -360 {lab=1.2V}
N 67320 -360 67690 -360 {lab=1.2V}
N 67600 -400 67600 -330 {lab=Vss}
N 67230 -330 67600 -330 {lab=Vss}
N 68190 -960 68190 -850 {lab=Gdrive}
N 68280 -960 68360 -960 {lab=Gdrive}
N 68360 -960 68360 -850 {lab=Gdrive}
N 68190 -790 68190 -700 {lab=Gate[45]}
N 68280 -700 68360 -700 {lab=Gate[45]}
N 68360 -790 68360 -700 {lab=Gate[45]}
N 68500 -790 68500 -650 {lab=Gate[45]}
N 68390 -650 68500 -650 {lab=Gate[45]}
N 68280 -700 68280 -650 {lab=Gate[45]}
N 68190 -700 68280 -700 {lab=Gate[45]}
N 68390 -650 68390 -570 {lab=Gate[45]}
N 68280 -650 68390 -650 {lab=Gate[45]}
N 68440 -820 68460 -820 {lab=ctrl_n[45]}
N 68690 -960 68690 -850 {lab=Ssense}
N 68780 -960 68860 -960 {lab=Ssense}
N 68860 -960 68860 -850 {lab=Ssense}
N 68690 -790 68690 -700 {lab=Source[45]}
N 68780 -700 68860 -700 {lab=Source[45]}
N 68860 -790 68860 -700 {lab=Source[45]}
N 68780 -700 68780 -650 {lab=Source[45]}
N 68690 -700 68780 -700 {lab=Source[45]}
N 69060 -960 69060 -850 {lab=Sforce}
N 69150 -960 69230 -960 {lab=Sforce}
N 69230 -960 69230 -850 {lab=Sforce}
N 69060 -790 69060 -700 {lab=Source[45]}
N 69150 -700 69230 -700 {lab=Source[45]}
N 69230 -790 69230 -700 {lab=Source[45]}
N 69150 -700 69150 -650 {lab=Source[45]}
N 69060 -700 69150 -700 {lab=Source[45]}
N 68960 -650 69150 -650 {lab=Source[45]}
N 69150 -1140 70650 -1140 {lab=Sforce}
N 69150 -1140 69150 -960 {lab=Sforce}
N 69060 -960 69150 -960 {lab=Sforce}
N 68780 -1170 70280 -1170 {lab=Ssense}
N 68780 -1170 68780 -960 {lab=Ssense}
N 68690 -960 68780 -960 {lab=Ssense}
N 68280 -1200 69780 -1200 {lab=Gdrive}
N 68280 -1200 68280 -960 {lab=Gdrive}
N 68190 -960 68280 -960 {lab=Gdrive}
N 68500 -1230 70000 -1230 {lab=Vcl}
N 68500 -1230 68500 -850 {lab=Vcl}
N 68740 -1380 68740 -1350 {lab=ctrl_p[45]}
N 68610 -1350 68740 -1350 {lab=ctrl_p[45]}
N 68110 -1350 68110 -820 {lab=ctrl_p[45]}
N 68110 -820 68150 -820 {lab=ctrl_p[45]}
N 68610 -820 68650 -820 {lab=ctrl_p[45]}
N 68610 -1350 68610 -820 {lab=ctrl_p[45]}
N 68110 -1350 68610 -1350 {lab=ctrl_p[45]}
N 68440 -1320 68440 -820 {lab=ctrl_n[45]}
N 68400 -820 68440 -820 {lab=ctrl_n[45]}
N 68440 -1320 68790 -1320 {lab=ctrl_n[45]}
N 68790 -1380 68790 -1320 {lab=ctrl_n[45]}
N 68900 -820 68940 -820 {lab=ctrl_n[45]}
N 68980 -820 69020 -820 {lab=ctrl_p[45]}
N 68940 -1320 69300 -1320 {lab=ctrl_n[45]}
N 68940 -1320 68940 -820 {lab=ctrl_n[45]}
N 68790 -1320 68940 -1320 {lab=ctrl_n[45]}
N 68740 -1350 68980 -1350 {lab=ctrl_p[45]}
N 68980 -1350 68980 -820 {lab=ctrl_p[45]}
N 69300 -1320 69300 -820 {lab=ctrl_n[45]}
N 69270 -820 69300 -820 {lab=ctrl_n[45]}
N 68960 -650 68960 -580 {lab=Source[45]}
N 68780 -650 68960 -650 {lab=Source[45]}
N 68190 -820 68230 -820 {lab=#net316}
N 68230 -820 68230 -460 {lab=#net316}
N 68500 -820 68540 -820 {lab=#net317}
N 68540 -820 68540 -460 {lab=#net317}
N 68230 -400 68230 -330 {lab=Vss}
N 69100 -330 69400 -330 {lab=Vss}
N 69400 -1080 69400 -330 {lab=Vss}
N 69400 -1080 70900 -1080 {lab=Vss}
N 69370 -1110 70870 -1110 {lab=1.2V}
N 69370 -1110 69370 -360 {lab=1.2V}
N 68540 -400 68540 -330 {lab=Vss}
N 68230 -330 68540 -330 {lab=Vss}
N 69190 -360 69370 -360 {lab=1.2V}
N 68820 -820 68860 -820 {lab=#net318}
N 68820 -820 68820 -460 {lab=#net318}
N 68690 -820 68730 -820 {lab=#net319}
N 68730 -820 68730 -460 {lab=#net319}
N 68820 -400 68820 -360 {lab=1.2V}
N 68730 -400 68730 -330 {lab=Vss}
N 68540 -330 68730 -330 {lab=Vss}
N 68310 -820 68360 -820 {lab=#net320}
N 68310 -820 68310 -460 {lab=#net320}
N 68310 -400 68310 -360 {lab=1.2V}
N 68310 -360 68820 -360 {lab=1.2V}
N 69060 -820 69100 -820 {lab=#net321}
N 69100 -820 69100 -460 {lab=#net321}
N 69190 -820 69230 -820 {lab=#net322}
N 69190 -820 69190 -460 {lab=#net322}
N 69190 -400 69190 -360 {lab=1.2V}
N 68820 -360 69190 -360 {lab=1.2V}
N 69100 -400 69100 -330 {lab=Vss}
N 68730 -330 69100 -330 {lab=Vss}
N 69690 -960 69690 -850 {lab=Gdrive}
N 69780 -960 69860 -960 {lab=Gdrive}
N 69860 -960 69860 -850 {lab=Gdrive}
N 69690 -790 69690 -700 {lab=Gate[46]}
N 69780 -700 69860 -700 {lab=Gate[46]}
N 69860 -790 69860 -700 {lab=Gate[46]}
N 70000 -790 70000 -650 {lab=Gate[46]}
N 69890 -650 70000 -650 {lab=Gate[46]}
N 69780 -700 69780 -650 {lab=Gate[46]}
N 69690 -700 69780 -700 {lab=Gate[46]}
N 69890 -650 69890 -570 {lab=Gate[46]}
N 69780 -650 69890 -650 {lab=Gate[46]}
N 69940 -820 69960 -820 {lab=ctrl_n[46]}
N 70190 -960 70190 -850 {lab=Ssense}
N 70280 -960 70360 -960 {lab=Ssense}
N 70360 -960 70360 -850 {lab=Ssense}
N 70190 -790 70190 -700 {lab=Source[46]}
N 70280 -700 70360 -700 {lab=Source[46]}
N 70360 -790 70360 -700 {lab=Source[46]}
N 70280 -700 70280 -650 {lab=Source[46]}
N 70190 -700 70280 -700 {lab=Source[46]}
N 70560 -960 70560 -850 {lab=Sforce}
N 70650 -960 70730 -960 {lab=Sforce}
N 70730 -960 70730 -850 {lab=Sforce}
N 70560 -790 70560 -700 {lab=Source[46]}
N 70650 -700 70730 -700 {lab=Source[46]}
N 70730 -790 70730 -700 {lab=Source[46]}
N 70650 -700 70650 -650 {lab=Source[46]}
N 70560 -700 70650 -700 {lab=Source[46]}
N 70460 -650 70650 -650 {lab=Source[46]}
N 70650 -1140 72150 -1140 {lab=Sforce}
N 70650 -1140 70650 -960 {lab=Sforce}
N 70560 -960 70650 -960 {lab=Sforce}
N 70280 -1170 71780 -1170 {lab=Ssense}
N 70280 -1170 70280 -960 {lab=Ssense}
N 70190 -960 70280 -960 {lab=Ssense}
N 69780 -1200 71280 -1200 {lab=Gdrive}
N 69780 -1200 69780 -960 {lab=Gdrive}
N 69690 -960 69780 -960 {lab=Gdrive}
N 70000 -1230 71500 -1230 {lab=Vcl}
N 70000 -1230 70000 -850 {lab=Vcl}
N 70240 -1380 70240 -1350 {lab=ctrl_p[46]}
N 70110 -1350 70240 -1350 {lab=ctrl_p[46]}
N 69610 -1350 69610 -820 {lab=ctrl_p[46]}
N 69610 -820 69650 -820 {lab=ctrl_p[46]}
N 70110 -820 70150 -820 {lab=ctrl_p[46]}
N 70110 -1350 70110 -820 {lab=ctrl_p[46]}
N 69610 -1350 70110 -1350 {lab=ctrl_p[46]}
N 69940 -1320 69940 -820 {lab=ctrl_n[46]}
N 69900 -820 69940 -820 {lab=ctrl_n[46]}
N 69940 -1320 70290 -1320 {lab=ctrl_n[46]}
N 70290 -1380 70290 -1320 {lab=ctrl_n[46]}
N 70400 -820 70440 -820 {lab=ctrl_n[46]}
N 70480 -820 70520 -820 {lab=ctrl_p[46]}
N 70440 -1320 70800 -1320 {lab=ctrl_n[46]}
N 70440 -1320 70440 -820 {lab=ctrl_n[46]}
N 70290 -1320 70440 -1320 {lab=ctrl_n[46]}
N 70240 -1350 70480 -1350 {lab=ctrl_p[46]}
N 70480 -1350 70480 -820 {lab=ctrl_p[46]}
N 70800 -1320 70800 -820 {lab=ctrl_n[46]}
N 70770 -820 70800 -820 {lab=ctrl_n[46]}
N 70460 -650 70460 -580 {lab=Source[46]}
N 70280 -650 70460 -650 {lab=Source[46]}
N 69690 -820 69730 -820 {lab=#net323}
N 69730 -820 69730 -460 {lab=#net323}
N 70000 -820 70040 -820 {lab=#net324}
N 70040 -820 70040 -460 {lab=#net324}
N 69730 -400 69730 -330 {lab=Vss}
N 70600 -330 70900 -330 {lab=Vss}
N 70900 -1080 70900 -330 {lab=Vss}
N 70900 -1080 72400 -1080 {lab=Vss}
N 70870 -1110 72370 -1110 {lab=1.2V}
N 70870 -1110 70870 -360 {lab=1.2V}
N 70040 -400 70040 -330 {lab=Vss}
N 69730 -330 70040 -330 {lab=Vss}
N 70690 -360 70870 -360 {lab=1.2V}
N 70320 -820 70360 -820 {lab=#net325}
N 70320 -820 70320 -460 {lab=#net325}
N 70190 -820 70230 -820 {lab=#net326}
N 70230 -820 70230 -460 {lab=#net326}
N 70320 -400 70320 -360 {lab=1.2V}
N 70230 -400 70230 -330 {lab=Vss}
N 70040 -330 70230 -330 {lab=Vss}
N 69810 -820 69860 -820 {lab=#net327}
N 69810 -820 69810 -460 {lab=#net327}
N 69810 -400 69810 -360 {lab=1.2V}
N 69810 -360 70320 -360 {lab=1.2V}
N 70560 -820 70600 -820 {lab=#net328}
N 70600 -820 70600 -460 {lab=#net328}
N 70690 -820 70730 -820 {lab=#net329}
N 70690 -820 70690 -460 {lab=#net329}
N 70690 -400 70690 -360 {lab=1.2V}
N 70320 -360 70690 -360 {lab=1.2V}
N 70600 -400 70600 -330 {lab=Vss}
N 70230 -330 70600 -330 {lab=Vss}
N 71190 -960 71190 -850 {lab=Gdrive}
N 71280 -960 71360 -960 {lab=Gdrive}
N 71360 -960 71360 -850 {lab=Gdrive}
N 71190 -790 71190 -700 {lab=Gate[47]}
N 71280 -700 71360 -700 {lab=Gate[47]}
N 71360 -790 71360 -700 {lab=Gate[47]}
N 71500 -790 71500 -650 {lab=Gate[47]}
N 71390 -650 71500 -650 {lab=Gate[47]}
N 71280 -700 71280 -650 {lab=Gate[47]}
N 71190 -700 71280 -700 {lab=Gate[47]}
N 71390 -650 71390 -570 {lab=Gate[47]}
N 71280 -650 71390 -650 {lab=Gate[47]}
N 71440 -820 71460 -820 {lab=ctrl_n[47]}
N 71690 -960 71690 -850 {lab=Ssense}
N 71780 -960 71860 -960 {lab=Ssense}
N 71860 -960 71860 -850 {lab=Ssense}
N 71690 -790 71690 -700 {lab=Source[47]}
N 71780 -700 71860 -700 {lab=Source[47]}
N 71860 -790 71860 -700 {lab=Source[47]}
N 71780 -700 71780 -650 {lab=Source[47]}
N 71690 -700 71780 -700 {lab=Source[47]}
N 72060 -960 72060 -850 {lab=Sforce}
N 72150 -960 72230 -960 {lab=Sforce}
N 72230 -960 72230 -850 {lab=Sforce}
N 72060 -790 72060 -700 {lab=Source[47]}
N 72150 -700 72230 -700 {lab=Source[47]}
N 72230 -790 72230 -700 {lab=Source[47]}
N 72150 -700 72150 -650 {lab=Source[47]}
N 72060 -700 72150 -700 {lab=Source[47]}
N 71960 -650 72150 -650 {lab=Source[47]}
N 72150 -1140 73650 -1140 {lab=Sforce}
N 72150 -1140 72150 -960 {lab=Sforce}
N 72060 -960 72150 -960 {lab=Sforce}
N 71780 -1170 73280 -1170 {lab=Ssense}
N 71780 -1170 71780 -960 {lab=Ssense}
N 71690 -960 71780 -960 {lab=Ssense}
N 71280 -1200 72780 -1200 {lab=Gdrive}
N 71280 -1200 71280 -960 {lab=Gdrive}
N 71190 -960 71280 -960 {lab=Gdrive}
N 71500 -1230 73000 -1230 {lab=Vcl}
N 71500 -1230 71500 -850 {lab=Vcl}
N 71740 -1380 71740 -1350 {lab=ctrl_p[47]}
N 71610 -1350 71740 -1350 {lab=ctrl_p[47]}
N 71110 -1350 71110 -820 {lab=ctrl_p[47]}
N 71110 -820 71150 -820 {lab=ctrl_p[47]}
N 71610 -820 71650 -820 {lab=ctrl_p[47]}
N 71610 -1350 71610 -820 {lab=ctrl_p[47]}
N 71110 -1350 71610 -1350 {lab=ctrl_p[47]}
N 71440 -1320 71440 -820 {lab=ctrl_n[47]}
N 71400 -820 71440 -820 {lab=ctrl_n[47]}
N 71440 -1320 71790 -1320 {lab=ctrl_n[47]}
N 71790 -1380 71790 -1320 {lab=ctrl_n[47]}
N 71900 -820 71940 -820 {lab=ctrl_n[47]}
N 71980 -820 72020 -820 {lab=ctrl_p[47]}
N 71940 -1320 72300 -1320 {lab=ctrl_n[47]}
N 71940 -1320 71940 -820 {lab=ctrl_n[47]}
N 71790 -1320 71940 -1320 {lab=ctrl_n[47]}
N 71740 -1350 71980 -1350 {lab=ctrl_p[47]}
N 71980 -1350 71980 -820 {lab=ctrl_p[47]}
N 72300 -1320 72300 -820 {lab=ctrl_n[47]}
N 72270 -820 72300 -820 {lab=ctrl_n[47]}
N 71960 -650 71960 -580 {lab=Source[47]}
N 71780 -650 71960 -650 {lab=Source[47]}
N 71190 -820 71230 -820 {lab=#net330}
N 71230 -820 71230 -460 {lab=#net330}
N 71500 -820 71540 -820 {lab=#net331}
N 71540 -820 71540 -460 {lab=#net331}
N 71230 -400 71230 -330 {lab=Vss}
N 72100 -330 72400 -330 {lab=Vss}
N 72400 -1080 72400 -330 {lab=Vss}
N 72400 -1080 73900 -1080 {lab=Vss}
N 72370 -1110 73870 -1110 {lab=1.2V}
N 72370 -1110 72370 -360 {lab=1.2V}
N 71540 -400 71540 -330 {lab=Vss}
N 71230 -330 71540 -330 {lab=Vss}
N 72190 -360 72370 -360 {lab=1.2V}
N 71820 -820 71860 -820 {lab=#net332}
N 71820 -820 71820 -460 {lab=#net332}
N 71690 -820 71730 -820 {lab=#net333}
N 71730 -820 71730 -460 {lab=#net333}
N 71820 -400 71820 -360 {lab=1.2V}
N 71730 -400 71730 -330 {lab=Vss}
N 71540 -330 71730 -330 {lab=Vss}
N 71310 -820 71360 -820 {lab=#net334}
N 71310 -820 71310 -460 {lab=#net334}
N 71310 -400 71310 -360 {lab=1.2V}
N 71310 -360 71820 -360 {lab=1.2V}
N 72060 -820 72100 -820 {lab=#net335}
N 72100 -820 72100 -460 {lab=#net335}
N 72190 -820 72230 -820 {lab=#net336}
N 72190 -820 72190 -460 {lab=#net336}
N 72190 -400 72190 -360 {lab=1.2V}
N 71820 -360 72190 -360 {lab=1.2V}
N 72100 -400 72100 -330 {lab=Vss}
N 71730 -330 72100 -330 {lab=Vss}
N 72690 -960 72690 -850 {lab=Gdrive}
N 72780 -960 72860 -960 {lab=Gdrive}
N 72860 -960 72860 -850 {lab=Gdrive}
N 72690 -790 72690 -700 {lab=Gate[48]}
N 72780 -700 72860 -700 {lab=Gate[48]}
N 72860 -790 72860 -700 {lab=Gate[48]}
N 73000 -790 73000 -650 {lab=Gate[48]}
N 72890 -650 73000 -650 {lab=Gate[48]}
N 72780 -700 72780 -650 {lab=Gate[48]}
N 72690 -700 72780 -700 {lab=Gate[48]}
N 72890 -650 72890 -570 {lab=Gate[48]}
N 72780 -650 72890 -650 {lab=Gate[48]}
N 72940 -820 72960 -820 {lab=ctrl_n[48]}
N 73190 -960 73190 -850 {lab=Ssense}
N 73280 -960 73360 -960 {lab=Ssense}
N 73360 -960 73360 -850 {lab=Ssense}
N 73190 -790 73190 -700 {lab=Source[48]}
N 73280 -700 73360 -700 {lab=Source[48]}
N 73360 -790 73360 -700 {lab=Source[48]}
N 73280 -700 73280 -650 {lab=Source[48]}
N 73190 -700 73280 -700 {lab=Source[48]}
N 73560 -960 73560 -850 {lab=Sforce}
N 73650 -960 73730 -960 {lab=Sforce}
N 73730 -960 73730 -850 {lab=Sforce}
N 73560 -790 73560 -700 {lab=Source[48]}
N 73650 -700 73730 -700 {lab=Source[48]}
N 73730 -790 73730 -700 {lab=Source[48]}
N 73650 -700 73650 -650 {lab=Source[48]}
N 73560 -700 73650 -700 {lab=Source[48]}
N 73460 -650 73650 -650 {lab=Source[48]}
N 73650 -1140 75150 -1140 {lab=Sforce}
N 73650 -1140 73650 -960 {lab=Sforce}
N 73560 -960 73650 -960 {lab=Sforce}
N 73280 -1170 74780 -1170 {lab=Ssense}
N 73280 -1170 73280 -960 {lab=Ssense}
N 73190 -960 73280 -960 {lab=Ssense}
N 72780 -1200 74280 -1200 {lab=Gdrive}
N 72780 -1200 72780 -960 {lab=Gdrive}
N 72690 -960 72780 -960 {lab=Gdrive}
N 73000 -1230 74500 -1230 {lab=Vcl}
N 73000 -1230 73000 -850 {lab=Vcl}
N 73240 -1380 73240 -1350 {lab=ctrl_p[48]}
N 73110 -1350 73240 -1350 {lab=ctrl_p[48]}
N 72610 -1350 72610 -820 {lab=ctrl_p[48]}
N 72610 -820 72650 -820 {lab=ctrl_p[48]}
N 73110 -820 73150 -820 {lab=ctrl_p[48]}
N 73110 -1350 73110 -820 {lab=ctrl_p[48]}
N 72610 -1350 73110 -1350 {lab=ctrl_p[48]}
N 72940 -1320 72940 -820 {lab=ctrl_n[48]}
N 72900 -820 72940 -820 {lab=ctrl_n[48]}
N 72940 -1320 73290 -1320 {lab=ctrl_n[48]}
N 73290 -1380 73290 -1320 {lab=ctrl_n[48]}
N 73400 -820 73440 -820 {lab=ctrl_n[48]}
N 73480 -820 73520 -820 {lab=ctrl_p[48]}
N 73440 -1320 73800 -1320 {lab=ctrl_n[48]}
N 73440 -1320 73440 -820 {lab=ctrl_n[48]}
N 73290 -1320 73440 -1320 {lab=ctrl_n[48]}
N 73240 -1350 73480 -1350 {lab=ctrl_p[48]}
N 73480 -1350 73480 -820 {lab=ctrl_p[48]}
N 73800 -1320 73800 -820 {lab=ctrl_n[48]}
N 73770 -820 73800 -820 {lab=ctrl_n[48]}
N 73460 -650 73460 -580 {lab=Source[48]}
N 73280 -650 73460 -650 {lab=Source[48]}
N 72690 -820 72730 -820 {lab=#net337}
N 72730 -820 72730 -460 {lab=#net337}
N 73000 -820 73040 -820 {lab=#net338}
N 73040 -820 73040 -460 {lab=#net338}
N 72730 -400 72730 -330 {lab=Vss}
N 73600 -330 73900 -330 {lab=Vss}
N 73900 -1080 73900 -330 {lab=Vss}
N 73900 -1080 75400 -1080 {lab=Vss}
N 73870 -1110 75370 -1110 {lab=1.2V}
N 73870 -1110 73870 -360 {lab=1.2V}
N 73040 -400 73040 -330 {lab=Vss}
N 72730 -330 73040 -330 {lab=Vss}
N 73690 -360 73870 -360 {lab=1.2V}
N 73320 -820 73360 -820 {lab=#net339}
N 73320 -820 73320 -460 {lab=#net339}
N 73190 -820 73230 -820 {lab=#net340}
N 73230 -820 73230 -460 {lab=#net340}
N 73320 -400 73320 -360 {lab=1.2V}
N 73230 -400 73230 -330 {lab=Vss}
N 73040 -330 73230 -330 {lab=Vss}
N 72810 -820 72860 -820 {lab=#net341}
N 72810 -820 72810 -460 {lab=#net341}
N 72810 -400 72810 -360 {lab=1.2V}
N 72810 -360 73320 -360 {lab=1.2V}
N 73560 -820 73600 -820 {lab=#net342}
N 73600 -820 73600 -460 {lab=#net342}
N 73690 -820 73730 -820 {lab=#net343}
N 73690 -820 73690 -460 {lab=#net343}
N 73690 -400 73690 -360 {lab=1.2V}
N 73320 -360 73690 -360 {lab=1.2V}
N 73600 -400 73600 -330 {lab=Vss}
N 73230 -330 73600 -330 {lab=Vss}
N 74190 -960 74190 -850 {lab=Gdrive}
N 74280 -960 74360 -960 {lab=Gdrive}
N 74360 -960 74360 -850 {lab=Gdrive}
N 74190 -790 74190 -700 {lab=Gate[49]}
N 74280 -700 74360 -700 {lab=Gate[49]}
N 74360 -790 74360 -700 {lab=Gate[49]}
N 74500 -790 74500 -650 {lab=Gate[49]}
N 74390 -650 74500 -650 {lab=Gate[49]}
N 74280 -700 74280 -650 {lab=Gate[49]}
N 74190 -700 74280 -700 {lab=Gate[49]}
N 74390 -650 74390 -570 {lab=Gate[49]}
N 74280 -650 74390 -650 {lab=Gate[49]}
N 74440 -820 74460 -820 {lab=ctrl_n[49]}
N 74690 -960 74690 -850 {lab=Ssense}
N 74780 -960 74860 -960 {lab=Ssense}
N 74860 -960 74860 -850 {lab=Ssense}
N 74690 -790 74690 -700 {lab=Source[49]}
N 74780 -700 74860 -700 {lab=Source[49]}
N 74860 -790 74860 -700 {lab=Source[49]}
N 74780 -700 74780 -650 {lab=Source[49]}
N 74690 -700 74780 -700 {lab=Source[49]}
N 75060 -960 75060 -850 {lab=Sforce}
N 75150 -960 75230 -960 {lab=Sforce}
N 75230 -960 75230 -850 {lab=Sforce}
N 75060 -790 75060 -700 {lab=Source[49]}
N 75150 -700 75230 -700 {lab=Source[49]}
N 75230 -790 75230 -700 {lab=Source[49]}
N 75150 -700 75150 -650 {lab=Source[49]}
N 75060 -700 75150 -700 {lab=Source[49]}
N 74960 -650 75150 -650 {lab=Source[49]}
N 75150 -1140 76650 -1140 {lab=Sforce}
N 75150 -1140 75150 -960 {lab=Sforce}
N 75060 -960 75150 -960 {lab=Sforce}
N 74780 -1170 76280 -1170 {lab=Ssense}
N 74780 -1170 74780 -960 {lab=Ssense}
N 74690 -960 74780 -960 {lab=Ssense}
N 74280 -1200 75780 -1200 {lab=Gdrive}
N 74280 -1200 74280 -960 {lab=Gdrive}
N 74190 -960 74280 -960 {lab=Gdrive}
N 74500 -1230 76000 -1230 {lab=Vcl}
N 74500 -1230 74500 -850 {lab=Vcl}
N 74740 -1380 74740 -1350 {lab=ctrl_p[49]}
N 74610 -1350 74740 -1350 {lab=ctrl_p[49]}
N 74110 -1350 74110 -820 {lab=ctrl_p[49]}
N 74110 -820 74150 -820 {lab=ctrl_p[49]}
N 74610 -820 74650 -820 {lab=ctrl_p[49]}
N 74610 -1350 74610 -820 {lab=ctrl_p[49]}
N 74110 -1350 74610 -1350 {lab=ctrl_p[49]}
N 74440 -1320 74440 -820 {lab=ctrl_n[49]}
N 74400 -820 74440 -820 {lab=ctrl_n[49]}
N 74440 -1320 74790 -1320 {lab=ctrl_n[49]}
N 74790 -1380 74790 -1320 {lab=ctrl_n[49]}
N 74900 -820 74940 -820 {lab=ctrl_n[49]}
N 74980 -820 75020 -820 {lab=ctrl_p[49]}
N 74940 -1320 75300 -1320 {lab=ctrl_n[49]}
N 74940 -1320 74940 -820 {lab=ctrl_n[49]}
N 74790 -1320 74940 -1320 {lab=ctrl_n[49]}
N 74740 -1350 74980 -1350 {lab=ctrl_p[49]}
N 74980 -1350 74980 -820 {lab=ctrl_p[49]}
N 75300 -1320 75300 -820 {lab=ctrl_n[49]}
N 75270 -820 75300 -820 {lab=ctrl_n[49]}
N 74960 -650 74960 -580 {lab=Source[49]}
N 74780 -650 74960 -650 {lab=Source[49]}
N 74190 -820 74230 -820 {lab=#net344}
N 74230 -820 74230 -460 {lab=#net344}
N 74500 -820 74540 -820 {lab=#net345}
N 74540 -820 74540 -460 {lab=#net345}
N 74230 -400 74230 -330 {lab=Vss}
N 75100 -330 75400 -330 {lab=Vss}
N 75400 -1080 75400 -330 {lab=Vss}
N 75400 -1080 76900 -1080 {lab=Vss}
N 75370 -1110 76870 -1110 {lab=1.2V}
N 75370 -1110 75370 -360 {lab=1.2V}
N 74540 -400 74540 -330 {lab=Vss}
N 74230 -330 74540 -330 {lab=Vss}
N 75190 -360 75370 -360 {lab=1.2V}
N 74820 -820 74860 -820 {lab=#net346}
N 74820 -820 74820 -460 {lab=#net346}
N 74690 -820 74730 -820 {lab=#net347}
N 74730 -820 74730 -460 {lab=#net347}
N 74820 -400 74820 -360 {lab=1.2V}
N 74730 -400 74730 -330 {lab=Vss}
N 74540 -330 74730 -330 {lab=Vss}
N 74310 -820 74360 -820 {lab=#net348}
N 74310 -820 74310 -460 {lab=#net348}
N 74310 -400 74310 -360 {lab=1.2V}
N 74310 -360 74820 -360 {lab=1.2V}
N 75060 -820 75100 -820 {lab=#net349}
N 75100 -820 75100 -460 {lab=#net349}
N 75190 -820 75230 -820 {lab=#net350}
N 75190 -820 75190 -460 {lab=#net350}
N 75190 -400 75190 -360 {lab=1.2V}
N 74820 -360 75190 -360 {lab=1.2V}
N 75100 -400 75100 -330 {lab=Vss}
N 74730 -330 75100 -330 {lab=Vss}
N 75690 -960 75690 -850 {lab=Gdrive}
N 75780 -960 75860 -960 {lab=Gdrive}
N 75860 -960 75860 -850 {lab=Gdrive}
N 75690 -790 75690 -700 {lab=Gate[50]}
N 75780 -700 75860 -700 {lab=Gate[50]}
N 75860 -790 75860 -700 {lab=Gate[50]}
N 76000 -790 76000 -650 {lab=Gate[50]}
N 75890 -650 76000 -650 {lab=Gate[50]}
N 75780 -700 75780 -650 {lab=Gate[50]}
N 75690 -700 75780 -700 {lab=Gate[50]}
N 75890 -650 75890 -570 {lab=Gate[50]}
N 75780 -650 75890 -650 {lab=Gate[50]}
N 75940 -820 75960 -820 {lab=ctrl_n[50]}
N 76190 -960 76190 -850 {lab=Ssense}
N 76280 -960 76360 -960 {lab=Ssense}
N 76360 -960 76360 -850 {lab=Ssense}
N 76190 -790 76190 -700 {lab=Source[50]}
N 76280 -700 76360 -700 {lab=Source[50]}
N 76360 -790 76360 -700 {lab=Source[50]}
N 76280 -700 76280 -650 {lab=Source[50]}
N 76190 -700 76280 -700 {lab=Source[50]}
N 76560 -960 76560 -850 {lab=Sforce}
N 76650 -960 76730 -960 {lab=Sforce}
N 76730 -960 76730 -850 {lab=Sforce}
N 76560 -790 76560 -700 {lab=Source[50]}
N 76650 -700 76730 -700 {lab=Source[50]}
N 76730 -790 76730 -700 {lab=Source[50]}
N 76650 -700 76650 -650 {lab=Source[50]}
N 76560 -700 76650 -700 {lab=Source[50]}
N 76460 -650 76650 -650 {lab=Source[50]}
N 76650 -1140 78150 -1140 {lab=Sforce}
N 76650 -1140 76650 -960 {lab=Sforce}
N 76560 -960 76650 -960 {lab=Sforce}
N 76280 -1170 77780 -1170 {lab=Ssense}
N 76280 -1170 76280 -960 {lab=Ssense}
N 76190 -960 76280 -960 {lab=Ssense}
N 75780 -1200 77280 -1200 {lab=Gdrive}
N 75780 -1200 75780 -960 {lab=Gdrive}
N 75690 -960 75780 -960 {lab=Gdrive}
N 76000 -1230 77500 -1230 {lab=Vcl}
N 76000 -1230 76000 -850 {lab=Vcl}
N 76240 -1380 76240 -1350 {lab=ctrl_p[50]}
N 76110 -1350 76240 -1350 {lab=ctrl_p[50]}
N 75610 -1350 75610 -820 {lab=ctrl_p[50]}
N 75610 -820 75650 -820 {lab=ctrl_p[50]}
N 76110 -820 76150 -820 {lab=ctrl_p[50]}
N 76110 -1350 76110 -820 {lab=ctrl_p[50]}
N 75610 -1350 76110 -1350 {lab=ctrl_p[50]}
N 75940 -1320 75940 -820 {lab=ctrl_n[50]}
N 75900 -820 75940 -820 {lab=ctrl_n[50]}
N 75940 -1320 76290 -1320 {lab=ctrl_n[50]}
N 76290 -1380 76290 -1320 {lab=ctrl_n[50]}
N 76400 -820 76440 -820 {lab=ctrl_n[50]}
N 76480 -820 76520 -820 {lab=ctrl_p[50]}
N 76440 -1320 76800 -1320 {lab=ctrl_n[50]}
N 76440 -1320 76440 -820 {lab=ctrl_n[50]}
N 76290 -1320 76440 -1320 {lab=ctrl_n[50]}
N 76240 -1350 76480 -1350 {lab=ctrl_p[50]}
N 76480 -1350 76480 -820 {lab=ctrl_p[50]}
N 76800 -1320 76800 -820 {lab=ctrl_n[50]}
N 76770 -820 76800 -820 {lab=ctrl_n[50]}
N 76460 -650 76460 -580 {lab=Source[50]}
N 76280 -650 76460 -650 {lab=Source[50]}
N 75690 -820 75730 -820 {lab=#net351}
N 75730 -820 75730 -460 {lab=#net351}
N 76000 -820 76040 -820 {lab=#net352}
N 76040 -820 76040 -460 {lab=#net352}
N 75730 -400 75730 -330 {lab=Vss}
N 76600 -330 76900 -330 {lab=Vss}
N 76900 -1080 76900 -330 {lab=Vss}
N 76900 -1080 78400 -1080 {lab=Vss}
N 76870 -1110 78370 -1110 {lab=1.2V}
N 76870 -1110 76870 -360 {lab=1.2V}
N 76040 -400 76040 -330 {lab=Vss}
N 75730 -330 76040 -330 {lab=Vss}
N 76690 -360 76870 -360 {lab=1.2V}
N 76320 -820 76360 -820 {lab=#net353}
N 76320 -820 76320 -460 {lab=#net353}
N 76190 -820 76230 -820 {lab=#net354}
N 76230 -820 76230 -460 {lab=#net354}
N 76320 -400 76320 -360 {lab=1.2V}
N 76230 -400 76230 -330 {lab=Vss}
N 76040 -330 76230 -330 {lab=Vss}
N 75810 -820 75860 -820 {lab=#net355}
N 75810 -820 75810 -460 {lab=#net355}
N 75810 -400 75810 -360 {lab=1.2V}
N 75810 -360 76320 -360 {lab=1.2V}
N 76560 -820 76600 -820 {lab=#net356}
N 76600 -820 76600 -460 {lab=#net356}
N 76690 -820 76730 -820 {lab=#net357}
N 76690 -820 76690 -460 {lab=#net357}
N 76690 -400 76690 -360 {lab=1.2V}
N 76320 -360 76690 -360 {lab=1.2V}
N 76600 -400 76600 -330 {lab=Vss}
N 76230 -330 76600 -330 {lab=Vss}
N 77190 -960 77190 -850 {lab=Gdrive}
N 77280 -960 77360 -960 {lab=Gdrive}
N 77360 -960 77360 -850 {lab=Gdrive}
N 77190 -790 77190 -700 {lab=Gate[51]}
N 77280 -700 77360 -700 {lab=Gate[51]}
N 77360 -790 77360 -700 {lab=Gate[51]}
N 77500 -790 77500 -650 {lab=Gate[51]}
N 77390 -650 77500 -650 {lab=Gate[51]}
N 77280 -700 77280 -650 {lab=Gate[51]}
N 77190 -700 77280 -700 {lab=Gate[51]}
N 77390 -650 77390 -570 {lab=Gate[51]}
N 77280 -650 77390 -650 {lab=Gate[51]}
N 77440 -820 77460 -820 {lab=ctrl_n[51]}
N 77690 -960 77690 -850 {lab=Ssense}
N 77780 -960 77860 -960 {lab=Ssense}
N 77860 -960 77860 -850 {lab=Ssense}
N 77690 -790 77690 -700 {lab=Source[51]}
N 77780 -700 77860 -700 {lab=Source[51]}
N 77860 -790 77860 -700 {lab=Source[51]}
N 77780 -700 77780 -650 {lab=Source[51]}
N 77690 -700 77780 -700 {lab=Source[51]}
N 78060 -960 78060 -850 {lab=Sforce}
N 78150 -960 78230 -960 {lab=Sforce}
N 78230 -960 78230 -850 {lab=Sforce}
N 78060 -790 78060 -700 {lab=Source[51]}
N 78150 -700 78230 -700 {lab=Source[51]}
N 78230 -790 78230 -700 {lab=Source[51]}
N 78150 -700 78150 -650 {lab=Source[51]}
N 78060 -700 78150 -700 {lab=Source[51]}
N 77960 -650 78150 -650 {lab=Source[51]}
N 78150 -1140 79650 -1140 {lab=Sforce}
N 78150 -1140 78150 -960 {lab=Sforce}
N 78060 -960 78150 -960 {lab=Sforce}
N 77780 -1170 79280 -1170 {lab=Ssense}
N 77780 -1170 77780 -960 {lab=Ssense}
N 77690 -960 77780 -960 {lab=Ssense}
N 77280 -1200 78780 -1200 {lab=Gdrive}
N 77280 -1200 77280 -960 {lab=Gdrive}
N 77190 -960 77280 -960 {lab=Gdrive}
N 77500 -1230 79000 -1230 {lab=Vcl}
N 77500 -1230 77500 -850 {lab=Vcl}
N 77740 -1380 77740 -1350 {lab=ctrl_p[51]}
N 77610 -1350 77740 -1350 {lab=ctrl_p[51]}
N 77110 -1350 77110 -820 {lab=ctrl_p[51]}
N 77110 -820 77150 -820 {lab=ctrl_p[51]}
N 77610 -820 77650 -820 {lab=ctrl_p[51]}
N 77610 -1350 77610 -820 {lab=ctrl_p[51]}
N 77110 -1350 77610 -1350 {lab=ctrl_p[51]}
N 77440 -1320 77440 -820 {lab=ctrl_n[51]}
N 77400 -820 77440 -820 {lab=ctrl_n[51]}
N 77440 -1320 77790 -1320 {lab=ctrl_n[51]}
N 77790 -1380 77790 -1320 {lab=ctrl_n[51]}
N 77900 -820 77940 -820 {lab=ctrl_n[51]}
N 77980 -820 78020 -820 {lab=ctrl_p[51]}
N 77940 -1320 78300 -1320 {lab=ctrl_n[51]}
N 77940 -1320 77940 -820 {lab=ctrl_n[51]}
N 77790 -1320 77940 -1320 {lab=ctrl_n[51]}
N 77740 -1350 77980 -1350 {lab=ctrl_p[51]}
N 77980 -1350 77980 -820 {lab=ctrl_p[51]}
N 78300 -1320 78300 -820 {lab=ctrl_n[51]}
N 78270 -820 78300 -820 {lab=ctrl_n[51]}
N 77960 -650 77960 -580 {lab=Source[51]}
N 77780 -650 77960 -650 {lab=Source[51]}
N 77190 -820 77230 -820 {lab=#net358}
N 77230 -820 77230 -460 {lab=#net358}
N 77500 -820 77540 -820 {lab=#net359}
N 77540 -820 77540 -460 {lab=#net359}
N 77230 -400 77230 -330 {lab=Vss}
N 78100 -330 78400 -330 {lab=Vss}
N 78400 -1080 78400 -330 {lab=Vss}
N 78400 -1080 79900 -1080 {lab=Vss}
N 78370 -1110 79870 -1110 {lab=1.2V}
N 78370 -1110 78370 -360 {lab=1.2V}
N 77540 -400 77540 -330 {lab=Vss}
N 77230 -330 77540 -330 {lab=Vss}
N 78190 -360 78370 -360 {lab=1.2V}
N 77820 -820 77860 -820 {lab=#net360}
N 77820 -820 77820 -460 {lab=#net360}
N 77690 -820 77730 -820 {lab=#net361}
N 77730 -820 77730 -460 {lab=#net361}
N 77820 -400 77820 -360 {lab=1.2V}
N 77730 -400 77730 -330 {lab=Vss}
N 77540 -330 77730 -330 {lab=Vss}
N 77310 -820 77360 -820 {lab=#net362}
N 77310 -820 77310 -460 {lab=#net362}
N 77310 -400 77310 -360 {lab=1.2V}
N 77310 -360 77820 -360 {lab=1.2V}
N 78060 -820 78100 -820 {lab=#net363}
N 78100 -820 78100 -460 {lab=#net363}
N 78190 -820 78230 -820 {lab=#net364}
N 78190 -820 78190 -460 {lab=#net364}
N 78190 -400 78190 -360 {lab=1.2V}
N 77820 -360 78190 -360 {lab=1.2V}
N 78100 -400 78100 -330 {lab=Vss}
N 77730 -330 78100 -330 {lab=Vss}
N 78690 -960 78690 -850 {lab=Gdrive}
N 78780 -960 78860 -960 {lab=Gdrive}
N 78860 -960 78860 -850 {lab=Gdrive}
N 78690 -790 78690 -700 {lab=Gate[52]}
N 78780 -700 78860 -700 {lab=Gate[52]}
N 78860 -790 78860 -700 {lab=Gate[52]}
N 79000 -790 79000 -650 {lab=Gate[52]}
N 78890 -650 79000 -650 {lab=Gate[52]}
N 78780 -700 78780 -650 {lab=Gate[52]}
N 78690 -700 78780 -700 {lab=Gate[52]}
N 78890 -650 78890 -570 {lab=Gate[52]}
N 78780 -650 78890 -650 {lab=Gate[52]}
N 78940 -820 78960 -820 {lab=ctrl_n[52]}
N 79190 -960 79190 -850 {lab=Ssense}
N 79280 -960 79360 -960 {lab=Ssense}
N 79360 -960 79360 -850 {lab=Ssense}
N 79190 -790 79190 -700 {lab=Source[52]}
N 79280 -700 79360 -700 {lab=Source[52]}
N 79360 -790 79360 -700 {lab=Source[52]}
N 79280 -700 79280 -650 {lab=Source[52]}
N 79190 -700 79280 -700 {lab=Source[52]}
N 79560 -960 79560 -850 {lab=Sforce}
N 79650 -960 79730 -960 {lab=Sforce}
N 79730 -960 79730 -850 {lab=Sforce}
N 79560 -790 79560 -700 {lab=Source[52]}
N 79650 -700 79730 -700 {lab=Source[52]}
N 79730 -790 79730 -700 {lab=Source[52]}
N 79650 -700 79650 -650 {lab=Source[52]}
N 79560 -700 79650 -700 {lab=Source[52]}
N 79460 -650 79650 -650 {lab=Source[52]}
N 79650 -1140 81150 -1140 {lab=Sforce}
N 79650 -1140 79650 -960 {lab=Sforce}
N 79560 -960 79650 -960 {lab=Sforce}
N 79280 -1170 80780 -1170 {lab=Ssense}
N 79280 -1170 79280 -960 {lab=Ssense}
N 79190 -960 79280 -960 {lab=Ssense}
N 78780 -1200 80280 -1200 {lab=Gdrive}
N 78780 -1200 78780 -960 {lab=Gdrive}
N 78690 -960 78780 -960 {lab=Gdrive}
N 79000 -1230 80500 -1230 {lab=Vcl}
N 79000 -1230 79000 -850 {lab=Vcl}
N 79240 -1380 79240 -1350 {lab=ctrl_p[52]}
N 79110 -1350 79240 -1350 {lab=ctrl_p[52]}
N 78610 -1350 78610 -820 {lab=ctrl_p[52]}
N 78610 -820 78650 -820 {lab=ctrl_p[52]}
N 79110 -820 79150 -820 {lab=ctrl_p[52]}
N 79110 -1350 79110 -820 {lab=ctrl_p[52]}
N 78610 -1350 79110 -1350 {lab=ctrl_p[52]}
N 78940 -1320 78940 -820 {lab=ctrl_n[52]}
N 78900 -820 78940 -820 {lab=ctrl_n[52]}
N 78940 -1320 79290 -1320 {lab=ctrl_n[52]}
N 79290 -1380 79290 -1320 {lab=ctrl_n[52]}
N 79400 -820 79440 -820 {lab=ctrl_n[52]}
N 79480 -820 79520 -820 {lab=ctrl_p[52]}
N 79440 -1320 79800 -1320 {lab=ctrl_n[52]}
N 79440 -1320 79440 -820 {lab=ctrl_n[52]}
N 79290 -1320 79440 -1320 {lab=ctrl_n[52]}
N 79240 -1350 79480 -1350 {lab=ctrl_p[52]}
N 79480 -1350 79480 -820 {lab=ctrl_p[52]}
N 79800 -1320 79800 -820 {lab=ctrl_n[52]}
N 79770 -820 79800 -820 {lab=ctrl_n[52]}
N 79460 -650 79460 -580 {lab=Source[52]}
N 79280 -650 79460 -650 {lab=Source[52]}
N 78690 -820 78730 -820 {lab=#net365}
N 78730 -820 78730 -460 {lab=#net365}
N 79000 -820 79040 -820 {lab=#net366}
N 79040 -820 79040 -460 {lab=#net366}
N 78730 -400 78730 -330 {lab=Vss}
N 79600 -330 79900 -330 {lab=Vss}
N 79900 -1080 79900 -330 {lab=Vss}
N 79900 -1080 81400 -1080 {lab=Vss}
N 79870 -1110 81370 -1110 {lab=1.2V}
N 79870 -1110 79870 -360 {lab=1.2V}
N 79040 -400 79040 -330 {lab=Vss}
N 78730 -330 79040 -330 {lab=Vss}
N 79690 -360 79870 -360 {lab=1.2V}
N 79320 -820 79360 -820 {lab=#net367}
N 79320 -820 79320 -460 {lab=#net367}
N 79190 -820 79230 -820 {lab=#net368}
N 79230 -820 79230 -460 {lab=#net368}
N 79320 -400 79320 -360 {lab=1.2V}
N 79230 -400 79230 -330 {lab=Vss}
N 79040 -330 79230 -330 {lab=Vss}
N 78810 -820 78860 -820 {lab=#net369}
N 78810 -820 78810 -460 {lab=#net369}
N 78810 -400 78810 -360 {lab=1.2V}
N 78810 -360 79320 -360 {lab=1.2V}
N 79560 -820 79600 -820 {lab=#net370}
N 79600 -820 79600 -460 {lab=#net370}
N 79690 -820 79730 -820 {lab=#net371}
N 79690 -820 79690 -460 {lab=#net371}
N 79690 -400 79690 -360 {lab=1.2V}
N 79320 -360 79690 -360 {lab=1.2V}
N 79600 -400 79600 -330 {lab=Vss}
N 79230 -330 79600 -330 {lab=Vss}
N 80190 -960 80190 -850 {lab=Gdrive}
N 80280 -960 80360 -960 {lab=Gdrive}
N 80360 -960 80360 -850 {lab=Gdrive}
N 80190 -790 80190 -700 {lab=Gate[53]}
N 80280 -700 80360 -700 {lab=Gate[53]}
N 80360 -790 80360 -700 {lab=Gate[53]}
N 80500 -790 80500 -650 {lab=Gate[53]}
N 80390 -650 80500 -650 {lab=Gate[53]}
N 80280 -700 80280 -650 {lab=Gate[53]}
N 80190 -700 80280 -700 {lab=Gate[53]}
N 80390 -650 80390 -570 {lab=Gate[53]}
N 80280 -650 80390 -650 {lab=Gate[53]}
N 80440 -820 80460 -820 {lab=ctrl_n[53]}
N 80690 -960 80690 -850 {lab=Ssense}
N 80780 -960 80860 -960 {lab=Ssense}
N 80860 -960 80860 -850 {lab=Ssense}
N 80690 -790 80690 -700 {lab=Source[53]}
N 80780 -700 80860 -700 {lab=Source[53]}
N 80860 -790 80860 -700 {lab=Source[53]}
N 80780 -700 80780 -650 {lab=Source[53]}
N 80690 -700 80780 -700 {lab=Source[53]}
N 81060 -960 81060 -850 {lab=Sforce}
N 81150 -960 81230 -960 {lab=Sforce}
N 81230 -960 81230 -850 {lab=Sforce}
N 81060 -790 81060 -700 {lab=Source[53]}
N 81150 -700 81230 -700 {lab=Source[53]}
N 81230 -790 81230 -700 {lab=Source[53]}
N 81150 -700 81150 -650 {lab=Source[53]}
N 81060 -700 81150 -700 {lab=Source[53]}
N 80960 -650 81150 -650 {lab=Source[53]}
N 81150 -1140 82650 -1140 {lab=Sforce}
N 81150 -1140 81150 -960 {lab=Sforce}
N 81060 -960 81150 -960 {lab=Sforce}
N 80780 -1170 82280 -1170 {lab=Ssense}
N 80780 -1170 80780 -960 {lab=Ssense}
N 80690 -960 80780 -960 {lab=Ssense}
N 80280 -1200 81780 -1200 {lab=Gdrive}
N 80280 -1200 80280 -960 {lab=Gdrive}
N 80190 -960 80280 -960 {lab=Gdrive}
N 80500 -1230 82000 -1230 {lab=Vcl}
N 80500 -1230 80500 -850 {lab=Vcl}
N 80740 -1380 80740 -1350 {lab=ctrl_p[53]}
N 80610 -1350 80740 -1350 {lab=ctrl_p[53]}
N 80110 -1350 80110 -820 {lab=ctrl_p[53]}
N 80110 -820 80150 -820 {lab=ctrl_p[53]}
N 80610 -820 80650 -820 {lab=ctrl_p[53]}
N 80610 -1350 80610 -820 {lab=ctrl_p[53]}
N 80110 -1350 80610 -1350 {lab=ctrl_p[53]}
N 80440 -1320 80440 -820 {lab=ctrl_n[53]}
N 80400 -820 80440 -820 {lab=ctrl_n[53]}
N 80440 -1320 80790 -1320 {lab=ctrl_n[53]}
N 80790 -1380 80790 -1320 {lab=ctrl_n[53]}
N 80900 -820 80940 -820 {lab=ctrl_n[53]}
N 80980 -820 81020 -820 {lab=ctrl_p[53]}
N 80940 -1320 81300 -1320 {lab=ctrl_n[53]}
N 80940 -1320 80940 -820 {lab=ctrl_n[53]}
N 80790 -1320 80940 -1320 {lab=ctrl_n[53]}
N 80740 -1350 80980 -1350 {lab=ctrl_p[53]}
N 80980 -1350 80980 -820 {lab=ctrl_p[53]}
N 81300 -1320 81300 -820 {lab=ctrl_n[53]}
N 81270 -820 81300 -820 {lab=ctrl_n[53]}
N 80960 -650 80960 -580 {lab=Source[53]}
N 80780 -650 80960 -650 {lab=Source[53]}
N 80190 -820 80230 -820 {lab=#net372}
N 80230 -820 80230 -460 {lab=#net372}
N 80500 -820 80540 -820 {lab=#net373}
N 80540 -820 80540 -460 {lab=#net373}
N 80230 -400 80230 -330 {lab=Vss}
N 81100 -330 81400 -330 {lab=Vss}
N 81400 -1080 81400 -330 {lab=Vss}
N 81400 -1080 82900 -1080 {lab=Vss}
N 81370 -1110 82870 -1110 {lab=1.2V}
N 81370 -1110 81370 -360 {lab=1.2V}
N 80540 -400 80540 -330 {lab=Vss}
N 80230 -330 80540 -330 {lab=Vss}
N 81190 -360 81370 -360 {lab=1.2V}
N 80820 -820 80860 -820 {lab=#net374}
N 80820 -820 80820 -460 {lab=#net374}
N 80690 -820 80730 -820 {lab=#net375}
N 80730 -820 80730 -460 {lab=#net375}
N 80820 -400 80820 -360 {lab=1.2V}
N 80730 -400 80730 -330 {lab=Vss}
N 80540 -330 80730 -330 {lab=Vss}
N 80310 -820 80360 -820 {lab=#net376}
N 80310 -820 80310 -460 {lab=#net376}
N 80310 -400 80310 -360 {lab=1.2V}
N 80310 -360 80820 -360 {lab=1.2V}
N 81060 -820 81100 -820 {lab=#net377}
N 81100 -820 81100 -460 {lab=#net377}
N 81190 -820 81230 -820 {lab=#net378}
N 81190 -820 81190 -460 {lab=#net378}
N 81190 -400 81190 -360 {lab=1.2V}
N 80820 -360 81190 -360 {lab=1.2V}
N 81100 -400 81100 -330 {lab=Vss}
N 80730 -330 81100 -330 {lab=Vss}
N 81690 -960 81690 -850 {lab=Gdrive}
N 81780 -960 81860 -960 {lab=Gdrive}
N 81860 -960 81860 -850 {lab=Gdrive}
N 81690 -790 81690 -700 {lab=Gate[54]}
N 81780 -700 81860 -700 {lab=Gate[54]}
N 81860 -790 81860 -700 {lab=Gate[54]}
N 82000 -790 82000 -650 {lab=Gate[54]}
N 81890 -650 82000 -650 {lab=Gate[54]}
N 81780 -700 81780 -650 {lab=Gate[54]}
N 81690 -700 81780 -700 {lab=Gate[54]}
N 81890 -650 81890 -570 {lab=Gate[54]}
N 81780 -650 81890 -650 {lab=Gate[54]}
N 81940 -820 81960 -820 {lab=ctrl_n[54]}
N 82190 -960 82190 -850 {lab=Ssense}
N 82280 -960 82360 -960 {lab=Ssense}
N 82360 -960 82360 -850 {lab=Ssense}
N 82190 -790 82190 -700 {lab=Source[54]}
N 82280 -700 82360 -700 {lab=Source[54]}
N 82360 -790 82360 -700 {lab=Source[54]}
N 82280 -700 82280 -650 {lab=Source[54]}
N 82190 -700 82280 -700 {lab=Source[54]}
N 82560 -960 82560 -850 {lab=Sforce}
N 82650 -960 82730 -960 {lab=Sforce}
N 82730 -960 82730 -850 {lab=Sforce}
N 82560 -790 82560 -700 {lab=Source[54]}
N 82650 -700 82730 -700 {lab=Source[54]}
N 82730 -790 82730 -700 {lab=Source[54]}
N 82650 -700 82650 -650 {lab=Source[54]}
N 82560 -700 82650 -700 {lab=Source[54]}
N 82460 -650 82650 -650 {lab=Source[54]}
N 82650 -1140 84150 -1140 {lab=Sforce}
N 82650 -1140 82650 -960 {lab=Sforce}
N 82560 -960 82650 -960 {lab=Sforce}
N 82280 -1170 83780 -1170 {lab=Ssense}
N 82280 -1170 82280 -960 {lab=Ssense}
N 82190 -960 82280 -960 {lab=Ssense}
N 81780 -1200 83280 -1200 {lab=Gdrive}
N 81780 -1200 81780 -960 {lab=Gdrive}
N 81690 -960 81780 -960 {lab=Gdrive}
N 82000 -1230 83500 -1230 {lab=Vcl}
N 82000 -1230 82000 -850 {lab=Vcl}
N 82240 -1380 82240 -1350 {lab=ctrl_p[54]}
N 82110 -1350 82240 -1350 {lab=ctrl_p[54]}
N 81610 -1350 81610 -820 {lab=ctrl_p[54]}
N 81610 -820 81650 -820 {lab=ctrl_p[54]}
N 82110 -820 82150 -820 {lab=ctrl_p[54]}
N 82110 -1350 82110 -820 {lab=ctrl_p[54]}
N 81610 -1350 82110 -1350 {lab=ctrl_p[54]}
N 81940 -1320 81940 -820 {lab=ctrl_n[54]}
N 81900 -820 81940 -820 {lab=ctrl_n[54]}
N 81940 -1320 82290 -1320 {lab=ctrl_n[54]}
N 82290 -1380 82290 -1320 {lab=ctrl_n[54]}
N 82400 -820 82440 -820 {lab=ctrl_n[54]}
N 82480 -820 82520 -820 {lab=ctrl_p[54]}
N 82440 -1320 82800 -1320 {lab=ctrl_n[54]}
N 82440 -1320 82440 -820 {lab=ctrl_n[54]}
N 82290 -1320 82440 -1320 {lab=ctrl_n[54]}
N 82240 -1350 82480 -1350 {lab=ctrl_p[54]}
N 82480 -1350 82480 -820 {lab=ctrl_p[54]}
N 82800 -1320 82800 -820 {lab=ctrl_n[54]}
N 82770 -820 82800 -820 {lab=ctrl_n[54]}
N 82460 -650 82460 -580 {lab=Source[54]}
N 82280 -650 82460 -650 {lab=Source[54]}
N 81690 -820 81730 -820 {lab=#net379}
N 81730 -820 81730 -460 {lab=#net379}
N 82000 -820 82040 -820 {lab=#net380}
N 82040 -820 82040 -460 {lab=#net380}
N 81730 -400 81730 -330 {lab=Vss}
N 82600 -330 82900 -330 {lab=Vss}
N 82900 -1080 82900 -330 {lab=Vss}
N 82900 -1080 84400 -1080 {lab=Vss}
N 82870 -1110 84370 -1110 {lab=1.2V}
N 82870 -1110 82870 -360 {lab=1.2V}
N 82040 -400 82040 -330 {lab=Vss}
N 81730 -330 82040 -330 {lab=Vss}
N 82690 -360 82870 -360 {lab=1.2V}
N 82320 -820 82360 -820 {lab=#net381}
N 82320 -820 82320 -460 {lab=#net381}
N 82190 -820 82230 -820 {lab=#net382}
N 82230 -820 82230 -460 {lab=#net382}
N 82320 -400 82320 -360 {lab=1.2V}
N 82230 -400 82230 -330 {lab=Vss}
N 82040 -330 82230 -330 {lab=Vss}
N 81810 -820 81860 -820 {lab=#net383}
N 81810 -820 81810 -460 {lab=#net383}
N 81810 -400 81810 -360 {lab=1.2V}
N 81810 -360 82320 -360 {lab=1.2V}
N 82560 -820 82600 -820 {lab=#net384}
N 82600 -820 82600 -460 {lab=#net384}
N 82690 -820 82730 -820 {lab=#net385}
N 82690 -820 82690 -460 {lab=#net385}
N 82690 -400 82690 -360 {lab=1.2V}
N 82320 -360 82690 -360 {lab=1.2V}
N 82600 -400 82600 -330 {lab=Vss}
N 82230 -330 82600 -330 {lab=Vss}
N 83190 -960 83190 -850 {lab=Gdrive}
N 83280 -960 83360 -960 {lab=Gdrive}
N 83360 -960 83360 -850 {lab=Gdrive}
N 83190 -790 83190 -700 {lab=Gate[55]}
N 83280 -700 83360 -700 {lab=Gate[55]}
N 83360 -790 83360 -700 {lab=Gate[55]}
N 83500 -790 83500 -650 {lab=Gate[55]}
N 83390 -650 83500 -650 {lab=Gate[55]}
N 83280 -700 83280 -650 {lab=Gate[55]}
N 83190 -700 83280 -700 {lab=Gate[55]}
N 83390 -650 83390 -570 {lab=Gate[55]}
N 83280 -650 83390 -650 {lab=Gate[55]}
N 83440 -820 83460 -820 {lab=ctrl_n[55]}
N 83690 -960 83690 -850 {lab=Ssense}
N 83780 -960 83860 -960 {lab=Ssense}
N 83860 -960 83860 -850 {lab=Ssense}
N 83690 -790 83690 -700 {lab=Source[55]}
N 83780 -700 83860 -700 {lab=Source[55]}
N 83860 -790 83860 -700 {lab=Source[55]}
N 83780 -700 83780 -650 {lab=Source[55]}
N 83690 -700 83780 -700 {lab=Source[55]}
N 84060 -960 84060 -850 {lab=Sforce}
N 84150 -960 84230 -960 {lab=Sforce}
N 84230 -960 84230 -850 {lab=Sforce}
N 84060 -790 84060 -700 {lab=Source[55]}
N 84150 -700 84230 -700 {lab=Source[55]}
N 84230 -790 84230 -700 {lab=Source[55]}
N 84150 -700 84150 -650 {lab=Source[55]}
N 84060 -700 84150 -700 {lab=Source[55]}
N 83960 -650 84150 -650 {lab=Source[55]}
N 84150 -1140 85650 -1140 {lab=Sforce}
N 84150 -1140 84150 -960 {lab=Sforce}
N 84060 -960 84150 -960 {lab=Sforce}
N 83780 -1170 85280 -1170 {lab=Ssense}
N 83780 -1170 83780 -960 {lab=Ssense}
N 83690 -960 83780 -960 {lab=Ssense}
N 83280 -1200 84780 -1200 {lab=Gdrive}
N 83280 -1200 83280 -960 {lab=Gdrive}
N 83190 -960 83280 -960 {lab=Gdrive}
N 83500 -1230 85000 -1230 {lab=Vcl}
N 83500 -1230 83500 -850 {lab=Vcl}
N 83740 -1380 83740 -1350 {lab=ctrl_p[55]}
N 83610 -1350 83740 -1350 {lab=ctrl_p[55]}
N 83110 -1350 83110 -820 {lab=ctrl_p[55]}
N 83110 -820 83150 -820 {lab=ctrl_p[55]}
N 83610 -820 83650 -820 {lab=ctrl_p[55]}
N 83610 -1350 83610 -820 {lab=ctrl_p[55]}
N 83110 -1350 83610 -1350 {lab=ctrl_p[55]}
N 83440 -1320 83440 -820 {lab=ctrl_n[55]}
N 83400 -820 83440 -820 {lab=ctrl_n[55]}
N 83440 -1320 83790 -1320 {lab=ctrl_n[55]}
N 83790 -1380 83790 -1320 {lab=ctrl_n[55]}
N 83900 -820 83940 -820 {lab=ctrl_n[55]}
N 83980 -820 84020 -820 {lab=ctrl_p[55]}
N 83940 -1320 84300 -1320 {lab=ctrl_n[55]}
N 83940 -1320 83940 -820 {lab=ctrl_n[55]}
N 83790 -1320 83940 -1320 {lab=ctrl_n[55]}
N 83740 -1350 83980 -1350 {lab=ctrl_p[55]}
N 83980 -1350 83980 -820 {lab=ctrl_p[55]}
N 84300 -1320 84300 -820 {lab=ctrl_n[55]}
N 84270 -820 84300 -820 {lab=ctrl_n[55]}
N 83960 -650 83960 -580 {lab=Source[55]}
N 83780 -650 83960 -650 {lab=Source[55]}
N 83190 -820 83230 -820 {lab=#net386}
N 83230 -820 83230 -460 {lab=#net386}
N 83500 -820 83540 -820 {lab=#net387}
N 83540 -820 83540 -460 {lab=#net387}
N 83230 -400 83230 -330 {lab=Vss}
N 84100 -330 84400 -330 {lab=Vss}
N 84400 -1080 84400 -330 {lab=Vss}
N 84400 -1080 85900 -1080 {lab=Vss}
N 84370 -1110 85870 -1110 {lab=1.2V}
N 84370 -1110 84370 -360 {lab=1.2V}
N 83540 -400 83540 -330 {lab=Vss}
N 83230 -330 83540 -330 {lab=Vss}
N 84190 -360 84370 -360 {lab=1.2V}
N 83820 -820 83860 -820 {lab=#net388}
N 83820 -820 83820 -460 {lab=#net388}
N 83690 -820 83730 -820 {lab=#net389}
N 83730 -820 83730 -460 {lab=#net389}
N 83820 -400 83820 -360 {lab=1.2V}
N 83730 -400 83730 -330 {lab=Vss}
N 83540 -330 83730 -330 {lab=Vss}
N 83310 -820 83360 -820 {lab=#net390}
N 83310 -820 83310 -460 {lab=#net390}
N 83310 -400 83310 -360 {lab=1.2V}
N 83310 -360 83820 -360 {lab=1.2V}
N 84060 -820 84100 -820 {lab=#net391}
N 84100 -820 84100 -460 {lab=#net391}
N 84190 -820 84230 -820 {lab=#net392}
N 84190 -820 84190 -460 {lab=#net392}
N 84190 -400 84190 -360 {lab=1.2V}
N 83820 -360 84190 -360 {lab=1.2V}
N 84100 -400 84100 -330 {lab=Vss}
N 83730 -330 84100 -330 {lab=Vss}
N 84690 -960 84690 -850 {lab=Gdrive}
N 84780 -960 84860 -960 {lab=Gdrive}
N 84860 -960 84860 -850 {lab=Gdrive}
N 84690 -790 84690 -700 {lab=Gate[56]}
N 84780 -700 84860 -700 {lab=Gate[56]}
N 84860 -790 84860 -700 {lab=Gate[56]}
N 85000 -790 85000 -650 {lab=Gate[56]}
N 84890 -650 85000 -650 {lab=Gate[56]}
N 84780 -700 84780 -650 {lab=Gate[56]}
N 84690 -700 84780 -700 {lab=Gate[56]}
N 84890 -650 84890 -570 {lab=Gate[56]}
N 84780 -650 84890 -650 {lab=Gate[56]}
N 84940 -820 84960 -820 {lab=ctrl_n[56]}
N 85190 -960 85190 -850 {lab=Ssense}
N 85280 -960 85360 -960 {lab=Ssense}
N 85360 -960 85360 -850 {lab=Ssense}
N 85190 -790 85190 -700 {lab=Source[56]}
N 85280 -700 85360 -700 {lab=Source[56]}
N 85360 -790 85360 -700 {lab=Source[56]}
N 85280 -700 85280 -650 {lab=Source[56]}
N 85190 -700 85280 -700 {lab=Source[56]}
N 85560 -960 85560 -850 {lab=Sforce}
N 85650 -960 85730 -960 {lab=Sforce}
N 85730 -960 85730 -850 {lab=Sforce}
N 85560 -790 85560 -700 {lab=Source[56]}
N 85650 -700 85730 -700 {lab=Source[56]}
N 85730 -790 85730 -700 {lab=Source[56]}
N 85650 -700 85650 -650 {lab=Source[56]}
N 85560 -700 85650 -700 {lab=Source[56]}
N 85460 -650 85650 -650 {lab=Source[56]}
N 85650 -1140 87150 -1140 {lab=Sforce}
N 85650 -1140 85650 -960 {lab=Sforce}
N 85560 -960 85650 -960 {lab=Sforce}
N 85280 -1170 86780 -1170 {lab=Ssense}
N 85280 -1170 85280 -960 {lab=Ssense}
N 85190 -960 85280 -960 {lab=Ssense}
N 84780 -1200 86280 -1200 {lab=Gdrive}
N 84780 -1200 84780 -960 {lab=Gdrive}
N 84690 -960 84780 -960 {lab=Gdrive}
N 85000 -1230 86500 -1230 {lab=Vcl}
N 85000 -1230 85000 -850 {lab=Vcl}
N 85240 -1380 85240 -1350 {lab=ctrl_p[56]}
N 85110 -1350 85240 -1350 {lab=ctrl_p[56]}
N 84610 -1350 84610 -820 {lab=ctrl_p[56]}
N 84610 -820 84650 -820 {lab=ctrl_p[56]}
N 85110 -820 85150 -820 {lab=ctrl_p[56]}
N 85110 -1350 85110 -820 {lab=ctrl_p[56]}
N 84610 -1350 85110 -1350 {lab=ctrl_p[56]}
N 84940 -1320 84940 -820 {lab=ctrl_n[56]}
N 84900 -820 84940 -820 {lab=ctrl_n[56]}
N 84940 -1320 85290 -1320 {lab=ctrl_n[56]}
N 85290 -1380 85290 -1320 {lab=ctrl_n[56]}
N 85400 -820 85440 -820 {lab=ctrl_n[56]}
N 85480 -820 85520 -820 {lab=ctrl_p[56]}
N 85440 -1320 85800 -1320 {lab=ctrl_n[56]}
N 85440 -1320 85440 -820 {lab=ctrl_n[56]}
N 85290 -1320 85440 -1320 {lab=ctrl_n[56]}
N 85240 -1350 85480 -1350 {lab=ctrl_p[56]}
N 85480 -1350 85480 -820 {lab=ctrl_p[56]}
N 85800 -1320 85800 -820 {lab=ctrl_n[56]}
N 85770 -820 85800 -820 {lab=ctrl_n[56]}
N 85460 -650 85460 -580 {lab=Source[56]}
N 85280 -650 85460 -650 {lab=Source[56]}
N 84690 -820 84730 -820 {lab=#net393}
N 84730 -820 84730 -460 {lab=#net393}
N 85000 -820 85040 -820 {lab=#net394}
N 85040 -820 85040 -460 {lab=#net394}
N 84730 -400 84730 -330 {lab=Vss}
N 85600 -330 85900 -330 {lab=Vss}
N 85900 -1080 85900 -330 {lab=Vss}
N 85900 -1080 87400 -1080 {lab=Vss}
N 85870 -1110 87370 -1110 {lab=1.2V}
N 85870 -1110 85870 -360 {lab=1.2V}
N 85040 -400 85040 -330 {lab=Vss}
N 84730 -330 85040 -330 {lab=Vss}
N 85690 -360 85870 -360 {lab=1.2V}
N 85320 -820 85360 -820 {lab=#net395}
N 85320 -820 85320 -460 {lab=#net395}
N 85190 -820 85230 -820 {lab=#net396}
N 85230 -820 85230 -460 {lab=#net396}
N 85320 -400 85320 -360 {lab=1.2V}
N 85230 -400 85230 -330 {lab=Vss}
N 85040 -330 85230 -330 {lab=Vss}
N 84810 -820 84860 -820 {lab=#net397}
N 84810 -820 84810 -460 {lab=#net397}
N 84810 -400 84810 -360 {lab=1.2V}
N 84810 -360 85320 -360 {lab=1.2V}
N 85560 -820 85600 -820 {lab=#net398}
N 85600 -820 85600 -460 {lab=#net398}
N 85690 -820 85730 -820 {lab=#net399}
N 85690 -820 85690 -460 {lab=#net399}
N 85690 -400 85690 -360 {lab=1.2V}
N 85320 -360 85690 -360 {lab=1.2V}
N 85600 -400 85600 -330 {lab=Vss}
N 85230 -330 85600 -330 {lab=Vss}
N 86190 -960 86190 -850 {lab=Gdrive}
N 86280 -960 86360 -960 {lab=Gdrive}
N 86360 -960 86360 -850 {lab=Gdrive}
N 86190 -790 86190 -700 {lab=Gate[57]}
N 86280 -700 86360 -700 {lab=Gate[57]}
N 86360 -790 86360 -700 {lab=Gate[57]}
N 86500 -790 86500 -650 {lab=Gate[57]}
N 86390 -650 86500 -650 {lab=Gate[57]}
N 86280 -700 86280 -650 {lab=Gate[57]}
N 86190 -700 86280 -700 {lab=Gate[57]}
N 86390 -650 86390 -570 {lab=Gate[57]}
N 86280 -650 86390 -650 {lab=Gate[57]}
N 86440 -820 86460 -820 {lab=ctrl_n[57]}
N 86690 -960 86690 -850 {lab=Ssense}
N 86780 -960 86860 -960 {lab=Ssense}
N 86860 -960 86860 -850 {lab=Ssense}
N 86690 -790 86690 -700 {lab=Source[57]}
N 86780 -700 86860 -700 {lab=Source[57]}
N 86860 -790 86860 -700 {lab=Source[57]}
N 86780 -700 86780 -650 {lab=Source[57]}
N 86690 -700 86780 -700 {lab=Source[57]}
N 87060 -960 87060 -850 {lab=Sforce}
N 87150 -960 87230 -960 {lab=Sforce}
N 87230 -960 87230 -850 {lab=Sforce}
N 87060 -790 87060 -700 {lab=Source[57]}
N 87150 -700 87230 -700 {lab=Source[57]}
N 87230 -790 87230 -700 {lab=Source[57]}
N 87150 -700 87150 -650 {lab=Source[57]}
N 87060 -700 87150 -700 {lab=Source[57]}
N 86960 -650 87150 -650 {lab=Source[57]}
N 87150 -1140 88650 -1140 {lab=Sforce}
N 87150 -1140 87150 -960 {lab=Sforce}
N 87060 -960 87150 -960 {lab=Sforce}
N 86780 -1170 88280 -1170 {lab=Ssense}
N 86780 -1170 86780 -960 {lab=Ssense}
N 86690 -960 86780 -960 {lab=Ssense}
N 86280 -1200 87780 -1200 {lab=Gdrive}
N 86280 -1200 86280 -960 {lab=Gdrive}
N 86190 -960 86280 -960 {lab=Gdrive}
N 86500 -1230 88000 -1230 {lab=Vcl}
N 86500 -1230 86500 -850 {lab=Vcl}
N 86740 -1380 86740 -1350 {lab=ctrl_p[57]}
N 86610 -1350 86740 -1350 {lab=ctrl_p[57]}
N 86110 -1350 86110 -820 {lab=ctrl_p[57]}
N 86110 -820 86150 -820 {lab=ctrl_p[57]}
N 86610 -820 86650 -820 {lab=ctrl_p[57]}
N 86610 -1350 86610 -820 {lab=ctrl_p[57]}
N 86110 -1350 86610 -1350 {lab=ctrl_p[57]}
N 86440 -1320 86440 -820 {lab=ctrl_n[57]}
N 86400 -820 86440 -820 {lab=ctrl_n[57]}
N 86440 -1320 86790 -1320 {lab=ctrl_n[57]}
N 86790 -1380 86790 -1320 {lab=ctrl_n[57]}
N 86900 -820 86940 -820 {lab=ctrl_n[57]}
N 86980 -820 87020 -820 {lab=ctrl_p[57]}
N 86940 -1320 87300 -1320 {lab=ctrl_n[57]}
N 86940 -1320 86940 -820 {lab=ctrl_n[57]}
N 86790 -1320 86940 -1320 {lab=ctrl_n[57]}
N 86740 -1350 86980 -1350 {lab=ctrl_p[57]}
N 86980 -1350 86980 -820 {lab=ctrl_p[57]}
N 87300 -1320 87300 -820 {lab=ctrl_n[57]}
N 87270 -820 87300 -820 {lab=ctrl_n[57]}
N 86960 -650 86960 -580 {lab=Source[57]}
N 86780 -650 86960 -650 {lab=Source[57]}
N 86190 -820 86230 -820 {lab=#net400}
N 86230 -820 86230 -460 {lab=#net400}
N 86500 -820 86540 -820 {lab=#net401}
N 86540 -820 86540 -460 {lab=#net401}
N 86230 -400 86230 -330 {lab=Vss}
N 87100 -330 87400 -330 {lab=Vss}
N 87400 -1080 87400 -330 {lab=Vss}
N 87400 -1080 88900 -1080 {lab=Vss}
N 87370 -1110 88870 -1110 {lab=1.2V}
N 87370 -1110 87370 -360 {lab=1.2V}
N 86540 -400 86540 -330 {lab=Vss}
N 86230 -330 86540 -330 {lab=Vss}
N 87190 -360 87370 -360 {lab=1.2V}
N 86820 -820 86860 -820 {lab=#net402}
N 86820 -820 86820 -460 {lab=#net402}
N 86690 -820 86730 -820 {lab=#net403}
N 86730 -820 86730 -460 {lab=#net403}
N 86820 -400 86820 -360 {lab=1.2V}
N 86730 -400 86730 -330 {lab=Vss}
N 86540 -330 86730 -330 {lab=Vss}
N 86310 -820 86360 -820 {lab=#net404}
N 86310 -820 86310 -460 {lab=#net404}
N 86310 -400 86310 -360 {lab=1.2V}
N 86310 -360 86820 -360 {lab=1.2V}
N 87060 -820 87100 -820 {lab=#net405}
N 87100 -820 87100 -460 {lab=#net405}
N 87190 -820 87230 -820 {lab=#net406}
N 87190 -820 87190 -460 {lab=#net406}
N 87190 -400 87190 -360 {lab=1.2V}
N 86820 -360 87190 -360 {lab=1.2V}
N 87100 -400 87100 -330 {lab=Vss}
N 86730 -330 87100 -330 {lab=Vss}
N 87690 -960 87690 -850 {lab=Gdrive}
N 87780 -960 87860 -960 {lab=Gdrive}
N 87860 -960 87860 -850 {lab=Gdrive}
N 87690 -790 87690 -700 {lab=Gate[58]}
N 87780 -700 87860 -700 {lab=Gate[58]}
N 87860 -790 87860 -700 {lab=Gate[58]}
N 88000 -790 88000 -650 {lab=Gate[58]}
N 87890 -650 88000 -650 {lab=Gate[58]}
N 87780 -700 87780 -650 {lab=Gate[58]}
N 87690 -700 87780 -700 {lab=Gate[58]}
N 87890 -650 87890 -570 {lab=Gate[58]}
N 87780 -650 87890 -650 {lab=Gate[58]}
N 87940 -820 87960 -820 {lab=ctrl_n[58]}
N 88190 -960 88190 -850 {lab=Ssense}
N 88280 -960 88360 -960 {lab=Ssense}
N 88360 -960 88360 -850 {lab=Ssense}
N 88190 -790 88190 -700 {lab=Source[58]}
N 88280 -700 88360 -700 {lab=Source[58]}
N 88360 -790 88360 -700 {lab=Source[58]}
N 88280 -700 88280 -650 {lab=Source[58]}
N 88190 -700 88280 -700 {lab=Source[58]}
N 88560 -960 88560 -850 {lab=Sforce}
N 88650 -960 88730 -960 {lab=Sforce}
N 88730 -960 88730 -850 {lab=Sforce}
N 88560 -790 88560 -700 {lab=Source[58]}
N 88650 -700 88730 -700 {lab=Source[58]}
N 88730 -790 88730 -700 {lab=Source[58]}
N 88650 -700 88650 -650 {lab=Source[58]}
N 88560 -700 88650 -700 {lab=Source[58]}
N 88460 -650 88650 -650 {lab=Source[58]}
N 88650 -1140 90150 -1140 {lab=Sforce}
N 88650 -1140 88650 -960 {lab=Sforce}
N 88560 -960 88650 -960 {lab=Sforce}
N 88280 -1170 89780 -1170 {lab=Ssense}
N 88280 -1170 88280 -960 {lab=Ssense}
N 88190 -960 88280 -960 {lab=Ssense}
N 87780 -1200 89280 -1200 {lab=Gdrive}
N 87780 -1200 87780 -960 {lab=Gdrive}
N 87690 -960 87780 -960 {lab=Gdrive}
N 88000 -1230 89500 -1230 {lab=Vcl}
N 88000 -1230 88000 -850 {lab=Vcl}
N 88240 -1380 88240 -1350 {lab=ctrl_p[58]}
N 88110 -1350 88240 -1350 {lab=ctrl_p[58]}
N 87610 -1350 87610 -820 {lab=ctrl_p[58]}
N 87610 -820 87650 -820 {lab=ctrl_p[58]}
N 88110 -820 88150 -820 {lab=ctrl_p[58]}
N 88110 -1350 88110 -820 {lab=ctrl_p[58]}
N 87610 -1350 88110 -1350 {lab=ctrl_p[58]}
N 87940 -1320 87940 -820 {lab=ctrl_n[58]}
N 87900 -820 87940 -820 {lab=ctrl_n[58]}
N 87940 -1320 88290 -1320 {lab=ctrl_n[58]}
N 88290 -1380 88290 -1320 {lab=ctrl_n[58]}
N 88400 -820 88440 -820 {lab=ctrl_n[58]}
N 88480 -820 88520 -820 {lab=ctrl_p[58]}
N 88440 -1320 88800 -1320 {lab=ctrl_n[58]}
N 88440 -1320 88440 -820 {lab=ctrl_n[58]}
N 88290 -1320 88440 -1320 {lab=ctrl_n[58]}
N 88240 -1350 88480 -1350 {lab=ctrl_p[58]}
N 88480 -1350 88480 -820 {lab=ctrl_p[58]}
N 88800 -1320 88800 -820 {lab=ctrl_n[58]}
N 88770 -820 88800 -820 {lab=ctrl_n[58]}
N 88460 -650 88460 -580 {lab=Source[58]}
N 88280 -650 88460 -650 {lab=Source[58]}
N 87690 -820 87730 -820 {lab=#net407}
N 87730 -820 87730 -460 {lab=#net407}
N 88000 -820 88040 -820 {lab=#net408}
N 88040 -820 88040 -460 {lab=#net408}
N 87730 -400 87730 -330 {lab=Vss}
N 88600 -330 88900 -330 {lab=Vss}
N 88900 -1080 88900 -330 {lab=Vss}
N 88900 -1080 90400 -1080 {lab=Vss}
N 88870 -1110 90370 -1110 {lab=1.2V}
N 88870 -1110 88870 -360 {lab=1.2V}
N 88040 -400 88040 -330 {lab=Vss}
N 87730 -330 88040 -330 {lab=Vss}
N 88690 -360 88870 -360 {lab=1.2V}
N 88320 -820 88360 -820 {lab=#net409}
N 88320 -820 88320 -460 {lab=#net409}
N 88190 -820 88230 -820 {lab=#net410}
N 88230 -820 88230 -460 {lab=#net410}
N 88320 -400 88320 -360 {lab=1.2V}
N 88230 -400 88230 -330 {lab=Vss}
N 88040 -330 88230 -330 {lab=Vss}
N 87810 -820 87860 -820 {lab=#net411}
N 87810 -820 87810 -460 {lab=#net411}
N 87810 -400 87810 -360 {lab=1.2V}
N 87810 -360 88320 -360 {lab=1.2V}
N 88560 -820 88600 -820 {lab=#net412}
N 88600 -820 88600 -460 {lab=#net412}
N 88690 -820 88730 -820 {lab=#net413}
N 88690 -820 88690 -460 {lab=#net413}
N 88690 -400 88690 -360 {lab=1.2V}
N 88320 -360 88690 -360 {lab=1.2V}
N 88600 -400 88600 -330 {lab=Vss}
N 88230 -330 88600 -330 {lab=Vss}
N 89190 -960 89190 -850 {lab=Gdrive}
N 89280 -960 89360 -960 {lab=Gdrive}
N 89360 -960 89360 -850 {lab=Gdrive}
N 89190 -790 89190 -700 {lab=Gate[59]}
N 89280 -700 89360 -700 {lab=Gate[59]}
N 89360 -790 89360 -700 {lab=Gate[59]}
N 89500 -790 89500 -650 {lab=Gate[59]}
N 89390 -650 89500 -650 {lab=Gate[59]}
N 89280 -700 89280 -650 {lab=Gate[59]}
N 89190 -700 89280 -700 {lab=Gate[59]}
N 89390 -650 89390 -570 {lab=Gate[59]}
N 89280 -650 89390 -650 {lab=Gate[59]}
N 89440 -820 89460 -820 {lab=ctrl_n[59]}
N 89690 -960 89690 -850 {lab=Ssense}
N 89780 -960 89860 -960 {lab=Ssense}
N 89860 -960 89860 -850 {lab=Ssense}
N 89690 -790 89690 -700 {lab=Source[59]}
N 89780 -700 89860 -700 {lab=Source[59]}
N 89860 -790 89860 -700 {lab=Source[59]}
N 89780 -700 89780 -650 {lab=Source[59]}
N 89690 -700 89780 -700 {lab=Source[59]}
N 90060 -960 90060 -850 {lab=Sforce}
N 90150 -960 90230 -960 {lab=Sforce}
N 90230 -960 90230 -850 {lab=Sforce}
N 90060 -790 90060 -700 {lab=Source[59]}
N 90150 -700 90230 -700 {lab=Source[59]}
N 90230 -790 90230 -700 {lab=Source[59]}
N 90150 -700 90150 -650 {lab=Source[59]}
N 90060 -700 90150 -700 {lab=Source[59]}
N 89960 -650 90150 -650 {lab=Source[59]}
N 90150 -1140 91650 -1140 {lab=Sforce}
N 90150 -1140 90150 -960 {lab=Sforce}
N 90060 -960 90150 -960 {lab=Sforce}
N 89780 -1170 91280 -1170 {lab=Ssense}
N 89780 -1170 89780 -960 {lab=Ssense}
N 89690 -960 89780 -960 {lab=Ssense}
N 89280 -1200 90780 -1200 {lab=Gdrive}
N 89280 -1200 89280 -960 {lab=Gdrive}
N 89190 -960 89280 -960 {lab=Gdrive}
N 89500 -1230 91000 -1230 {lab=Vcl}
N 89500 -1230 89500 -850 {lab=Vcl}
N 89740 -1380 89740 -1350 {lab=ctrl_p[59]}
N 89610 -1350 89740 -1350 {lab=ctrl_p[59]}
N 89110 -1350 89110 -820 {lab=ctrl_p[59]}
N 89110 -820 89150 -820 {lab=ctrl_p[59]}
N 89610 -820 89650 -820 {lab=ctrl_p[59]}
N 89610 -1350 89610 -820 {lab=ctrl_p[59]}
N 89110 -1350 89610 -1350 {lab=ctrl_p[59]}
N 89440 -1320 89440 -820 {lab=ctrl_n[59]}
N 89400 -820 89440 -820 {lab=ctrl_n[59]}
N 89440 -1320 89790 -1320 {lab=ctrl_n[59]}
N 89790 -1380 89790 -1320 {lab=ctrl_n[59]}
N 89900 -820 89940 -820 {lab=ctrl_n[59]}
N 89980 -820 90020 -820 {lab=ctrl_p[59]}
N 89940 -1320 90300 -1320 {lab=ctrl_n[59]}
N 89940 -1320 89940 -820 {lab=ctrl_n[59]}
N 89790 -1320 89940 -1320 {lab=ctrl_n[59]}
N 89740 -1350 89980 -1350 {lab=ctrl_p[59]}
N 89980 -1350 89980 -820 {lab=ctrl_p[59]}
N 90300 -1320 90300 -820 {lab=ctrl_n[59]}
N 90270 -820 90300 -820 {lab=ctrl_n[59]}
N 89960 -650 89960 -580 {lab=Source[59]}
N 89780 -650 89960 -650 {lab=Source[59]}
N 89190 -820 89230 -820 {lab=#net414}
N 89230 -820 89230 -460 {lab=#net414}
N 89500 -820 89540 -820 {lab=#net415}
N 89540 -820 89540 -460 {lab=#net415}
N 89230 -400 89230 -330 {lab=Vss}
N 90100 -330 90400 -330 {lab=Vss}
N 90400 -1080 90400 -330 {lab=Vss}
N 90400 -1080 91900 -1080 {lab=Vss}
N 90370 -1110 91870 -1110 {lab=1.2V}
N 90370 -1110 90370 -360 {lab=1.2V}
N 89540 -400 89540 -330 {lab=Vss}
N 89230 -330 89540 -330 {lab=Vss}
N 90190 -360 90370 -360 {lab=1.2V}
N 89820 -820 89860 -820 {lab=#net416}
N 89820 -820 89820 -460 {lab=#net416}
N 89690 -820 89730 -820 {lab=#net417}
N 89730 -820 89730 -460 {lab=#net417}
N 89820 -400 89820 -360 {lab=1.2V}
N 89730 -400 89730 -330 {lab=Vss}
N 89540 -330 89730 -330 {lab=Vss}
N 89310 -820 89360 -820 {lab=#net418}
N 89310 -820 89310 -460 {lab=#net418}
N 89310 -400 89310 -360 {lab=1.2V}
N 89310 -360 89820 -360 {lab=1.2V}
N 90060 -820 90100 -820 {lab=#net419}
N 90100 -820 90100 -460 {lab=#net419}
N 90190 -820 90230 -820 {lab=#net420}
N 90190 -820 90190 -460 {lab=#net420}
N 90190 -400 90190 -360 {lab=1.2V}
N 89820 -360 90190 -360 {lab=1.2V}
N 90100 -400 90100 -330 {lab=Vss}
N 89730 -330 90100 -330 {lab=Vss}
N 90690 -960 90690 -850 {lab=Gdrive}
N 90780 -960 90860 -960 {lab=Gdrive}
N 90860 -960 90860 -850 {lab=Gdrive}
N 90690 -790 90690 -700 {lab=Gate[60]}
N 90780 -700 90860 -700 {lab=Gate[60]}
N 90860 -790 90860 -700 {lab=Gate[60]}
N 91000 -790 91000 -650 {lab=Gate[60]}
N 90890 -650 91000 -650 {lab=Gate[60]}
N 90780 -700 90780 -650 {lab=Gate[60]}
N 90690 -700 90780 -700 {lab=Gate[60]}
N 90890 -650 90890 -570 {lab=Gate[60]}
N 90780 -650 90890 -650 {lab=Gate[60]}
N 90940 -820 90960 -820 {lab=ctrl_n[60]}
N 91190 -960 91190 -850 {lab=Ssense}
N 91280 -960 91360 -960 {lab=Ssense}
N 91360 -960 91360 -850 {lab=Ssense}
N 91190 -790 91190 -700 {lab=Source[60]}
N 91280 -700 91360 -700 {lab=Source[60]}
N 91360 -790 91360 -700 {lab=Source[60]}
N 91280 -700 91280 -650 {lab=Source[60]}
N 91190 -700 91280 -700 {lab=Source[60]}
N 91560 -960 91560 -850 {lab=Sforce}
N 91650 -960 91730 -960 {lab=Sforce}
N 91730 -960 91730 -850 {lab=Sforce}
N 91560 -790 91560 -700 {lab=Source[60]}
N 91650 -700 91730 -700 {lab=Source[60]}
N 91730 -790 91730 -700 {lab=Source[60]}
N 91650 -700 91650 -650 {lab=Source[60]}
N 91560 -700 91650 -700 {lab=Source[60]}
N 91460 -650 91650 -650 {lab=Source[60]}
N 91650 -1140 93150 -1140 {lab=Sforce}
N 91650 -1140 91650 -960 {lab=Sforce}
N 91560 -960 91650 -960 {lab=Sforce}
N 91280 -1170 92780 -1170 {lab=Ssense}
N 91280 -1170 91280 -960 {lab=Ssense}
N 91190 -960 91280 -960 {lab=Ssense}
N 90780 -1200 92280 -1200 {lab=Gdrive}
N 90780 -1200 90780 -960 {lab=Gdrive}
N 90690 -960 90780 -960 {lab=Gdrive}
N 91000 -1230 92500 -1230 {lab=Vcl}
N 91000 -1230 91000 -850 {lab=Vcl}
N 91240 -1380 91240 -1350 {lab=ctrl_p[60]}
N 91110 -1350 91240 -1350 {lab=ctrl_p[60]}
N 90610 -1350 90610 -820 {lab=ctrl_p[60]}
N 90610 -820 90650 -820 {lab=ctrl_p[60]}
N 91110 -820 91150 -820 {lab=ctrl_p[60]}
N 91110 -1350 91110 -820 {lab=ctrl_p[60]}
N 90610 -1350 91110 -1350 {lab=ctrl_p[60]}
N 90940 -1320 90940 -820 {lab=ctrl_n[60]}
N 90900 -820 90940 -820 {lab=ctrl_n[60]}
N 90940 -1320 91290 -1320 {lab=ctrl_n[60]}
N 91290 -1380 91290 -1320 {lab=ctrl_n[60]}
N 91400 -820 91440 -820 {lab=ctrl_n[60]}
N 91480 -820 91520 -820 {lab=ctrl_p[60]}
N 91440 -1320 91800 -1320 {lab=ctrl_n[60]}
N 91440 -1320 91440 -820 {lab=ctrl_n[60]}
N 91290 -1320 91440 -1320 {lab=ctrl_n[60]}
N 91240 -1350 91480 -1350 {lab=ctrl_p[60]}
N 91480 -1350 91480 -820 {lab=ctrl_p[60]}
N 91800 -1320 91800 -820 {lab=ctrl_n[60]}
N 91770 -820 91800 -820 {lab=ctrl_n[60]}
N 91460 -650 91460 -580 {lab=Source[60]}
N 91280 -650 91460 -650 {lab=Source[60]}
N 90690 -820 90730 -820 {lab=#net421}
N 90730 -820 90730 -460 {lab=#net421}
N 91000 -820 91040 -820 {lab=#net422}
N 91040 -820 91040 -460 {lab=#net422}
N 90730 -400 90730 -330 {lab=Vss}
N 91600 -330 91900 -330 {lab=Vss}
N 91900 -1080 91900 -330 {lab=Vss}
N 91900 -1080 93400 -1080 {lab=Vss}
N 91870 -1110 93370 -1110 {lab=1.2V}
N 91870 -1110 91870 -360 {lab=1.2V}
N 91040 -400 91040 -330 {lab=Vss}
N 90730 -330 91040 -330 {lab=Vss}
N 91690 -360 91870 -360 {lab=1.2V}
N 91320 -820 91360 -820 {lab=#net423}
N 91320 -820 91320 -460 {lab=#net423}
N 91190 -820 91230 -820 {lab=#net424}
N 91230 -820 91230 -460 {lab=#net424}
N 91320 -400 91320 -360 {lab=1.2V}
N 91230 -400 91230 -330 {lab=Vss}
N 91040 -330 91230 -330 {lab=Vss}
N 90810 -820 90860 -820 {lab=#net425}
N 90810 -820 90810 -460 {lab=#net425}
N 90810 -400 90810 -360 {lab=1.2V}
N 90810 -360 91320 -360 {lab=1.2V}
N 91560 -820 91600 -820 {lab=#net426}
N 91600 -820 91600 -460 {lab=#net426}
N 91690 -820 91730 -820 {lab=#net427}
N 91690 -820 91690 -460 {lab=#net427}
N 91690 -400 91690 -360 {lab=1.2V}
N 91320 -360 91690 -360 {lab=1.2V}
N 91600 -400 91600 -330 {lab=Vss}
N 91230 -330 91600 -330 {lab=Vss}
N 92190 -960 92190 -850 {lab=Gdrive}
N 92280 -960 92360 -960 {lab=Gdrive}
N 92360 -960 92360 -850 {lab=Gdrive}
N 92190 -790 92190 -700 {lab=Gate[61]}
N 92280 -700 92360 -700 {lab=Gate[61]}
N 92360 -790 92360 -700 {lab=Gate[61]}
N 92500 -790 92500 -650 {lab=Gate[61]}
N 92390 -650 92500 -650 {lab=Gate[61]}
N 92280 -700 92280 -650 {lab=Gate[61]}
N 92190 -700 92280 -700 {lab=Gate[61]}
N 92390 -650 92390 -570 {lab=Gate[61]}
N 92280 -650 92390 -650 {lab=Gate[61]}
N 92440 -820 92460 -820 {lab=ctrl_n[61]}
N 92690 -960 92690 -850 {lab=Ssense}
N 92780 -960 92860 -960 {lab=Ssense}
N 92860 -960 92860 -850 {lab=Ssense}
N 92690 -790 92690 -700 {lab=Source[61]}
N 92780 -700 92860 -700 {lab=Source[61]}
N 92860 -790 92860 -700 {lab=Source[61]}
N 92780 -700 92780 -650 {lab=Source[61]}
N 92690 -700 92780 -700 {lab=Source[61]}
N 93060 -960 93060 -850 {lab=Sforce}
N 93150 -960 93230 -960 {lab=Sforce}
N 93230 -960 93230 -850 {lab=Sforce}
N 93060 -790 93060 -700 {lab=Source[61]}
N 93150 -700 93230 -700 {lab=Source[61]}
N 93230 -790 93230 -700 {lab=Source[61]}
N 93150 -700 93150 -650 {lab=Source[61]}
N 93060 -700 93150 -700 {lab=Source[61]}
N 92960 -650 93150 -650 {lab=Source[61]}
N 93150 -1140 94650 -1140 {lab=Sforce}
N 93150 -1140 93150 -960 {lab=Sforce}
N 93060 -960 93150 -960 {lab=Sforce}
N 92780 -1170 94280 -1170 {lab=Ssense}
N 92780 -1170 92780 -960 {lab=Ssense}
N 92690 -960 92780 -960 {lab=Ssense}
N 92280 -1200 93780 -1200 {lab=Gdrive}
N 92280 -1200 92280 -960 {lab=Gdrive}
N 92190 -960 92280 -960 {lab=Gdrive}
N 92500 -1230 94000 -1230 {lab=Vcl}
N 92500 -1230 92500 -850 {lab=Vcl}
N 92740 -1380 92740 -1350 {lab=ctrl_p[61]}
N 92610 -1350 92740 -1350 {lab=ctrl_p[61]}
N 92110 -1350 92110 -820 {lab=ctrl_p[61]}
N 92110 -820 92150 -820 {lab=ctrl_p[61]}
N 92610 -820 92650 -820 {lab=ctrl_p[61]}
N 92610 -1350 92610 -820 {lab=ctrl_p[61]}
N 92110 -1350 92610 -1350 {lab=ctrl_p[61]}
N 92440 -1320 92440 -820 {lab=ctrl_n[61]}
N 92400 -820 92440 -820 {lab=ctrl_n[61]}
N 92440 -1320 92790 -1320 {lab=ctrl_n[61]}
N 92790 -1380 92790 -1320 {lab=ctrl_n[61]}
N 92900 -820 92940 -820 {lab=ctrl_n[61]}
N 92980 -820 93020 -820 {lab=ctrl_p[61]}
N 92940 -1320 93300 -1320 {lab=ctrl_n[61]}
N 92940 -1320 92940 -820 {lab=ctrl_n[61]}
N 92790 -1320 92940 -1320 {lab=ctrl_n[61]}
N 92740 -1350 92980 -1350 {lab=ctrl_p[61]}
N 92980 -1350 92980 -820 {lab=ctrl_p[61]}
N 93300 -1320 93300 -820 {lab=ctrl_n[61]}
N 93270 -820 93300 -820 {lab=ctrl_n[61]}
N 92960 -650 92960 -580 {lab=Source[61]}
N 92780 -650 92960 -650 {lab=Source[61]}
N 92190 -820 92230 -820 {lab=#net428}
N 92230 -820 92230 -460 {lab=#net428}
N 92500 -820 92540 -820 {lab=#net429}
N 92540 -820 92540 -460 {lab=#net429}
N 92230 -400 92230 -330 {lab=Vss}
N 93100 -330 93400 -330 {lab=Vss}
N 93400 -1080 93400 -330 {lab=Vss}
N 93400 -1080 94900 -1080 {lab=Vss}
N 93370 -1110 94870 -1110 {lab=1.2V}
N 93370 -1110 93370 -360 {lab=1.2V}
N 92540 -400 92540 -330 {lab=Vss}
N 92230 -330 92540 -330 {lab=Vss}
N 93190 -360 93370 -360 {lab=1.2V}
N 92820 -820 92860 -820 {lab=#net430}
N 92820 -820 92820 -460 {lab=#net430}
N 92690 -820 92730 -820 {lab=#net431}
N 92730 -820 92730 -460 {lab=#net431}
N 92820 -400 92820 -360 {lab=1.2V}
N 92730 -400 92730 -330 {lab=Vss}
N 92540 -330 92730 -330 {lab=Vss}
N 92310 -820 92360 -820 {lab=#net432}
N 92310 -820 92310 -460 {lab=#net432}
N 92310 -400 92310 -360 {lab=1.2V}
N 92310 -360 92820 -360 {lab=1.2V}
N 93060 -820 93100 -820 {lab=#net433}
N 93100 -820 93100 -460 {lab=#net433}
N 93190 -820 93230 -820 {lab=#net434}
N 93190 -820 93190 -460 {lab=#net434}
N 93190 -400 93190 -360 {lab=1.2V}
N 92820 -360 93190 -360 {lab=1.2V}
N 93100 -400 93100 -330 {lab=Vss}
N 92730 -330 93100 -330 {lab=Vss}
N 93690 -960 93690 -850 {lab=Gdrive}
N 93780 -960 93860 -960 {lab=Gdrive}
N 93860 -960 93860 -850 {lab=Gdrive}
N 93690 -790 93690 -700 {lab=Gate[62]}
N 93780 -700 93860 -700 {lab=Gate[62]}
N 93860 -790 93860 -700 {lab=Gate[62]}
N 94000 -790 94000 -650 {lab=Gate[62]}
N 93890 -650 94000 -650 {lab=Gate[62]}
N 93780 -700 93780 -650 {lab=Gate[62]}
N 93690 -700 93780 -700 {lab=Gate[62]}
N 93890 -650 93890 -570 {lab=Gate[62]}
N 93780 -650 93890 -650 {lab=Gate[62]}
N 93940 -820 93960 -820 {lab=ctrl_n[62]}
N 94190 -960 94190 -850 {lab=Ssense}
N 94280 -960 94360 -960 {lab=Ssense}
N 94360 -960 94360 -850 {lab=Ssense}
N 94190 -790 94190 -700 {lab=Source[62]}
N 94280 -700 94360 -700 {lab=Source[62]}
N 94360 -790 94360 -700 {lab=Source[62]}
N 94280 -700 94280 -650 {lab=Source[62]}
N 94190 -700 94280 -700 {lab=Source[62]}
N 94560 -960 94560 -850 {lab=Sforce}
N 94650 -960 94730 -960 {lab=Sforce}
N 94730 -960 94730 -850 {lab=Sforce}
N 94560 -790 94560 -700 {lab=Source[62]}
N 94650 -700 94730 -700 {lab=Source[62]}
N 94730 -790 94730 -700 {lab=Source[62]}
N 94650 -700 94650 -650 {lab=Source[62]}
N 94560 -700 94650 -700 {lab=Source[62]}
N 94460 -650 94650 -650 {lab=Source[62]}
N 94650 -1140 96150 -1140 {lab=Sforce}
N 94650 -1140 94650 -960 {lab=Sforce}
N 94560 -960 94650 -960 {lab=Sforce}
N 94280 -1170 95780 -1170 {lab=Ssense}
N 94280 -1170 94280 -960 {lab=Ssense}
N 94190 -960 94280 -960 {lab=Ssense}
N 93780 -1200 95280 -1200 {lab=Gdrive}
N 93780 -1200 93780 -960 {lab=Gdrive}
N 93690 -960 93780 -960 {lab=Gdrive}
N 94000 -1230 95500 -1230 {lab=Vcl}
N 94000 -1230 94000 -850 {lab=Vcl}
N 94240 -1380 94240 -1350 {lab=ctrl_p[62]}
N 94110 -1350 94240 -1350 {lab=ctrl_p[62]}
N 93610 -1350 93610 -820 {lab=ctrl_p[62]}
N 93610 -820 93650 -820 {lab=ctrl_p[62]}
N 94110 -820 94150 -820 {lab=ctrl_p[62]}
N 94110 -1350 94110 -820 {lab=ctrl_p[62]}
N 93610 -1350 94110 -1350 {lab=ctrl_p[62]}
N 93940 -1320 93940 -820 {lab=ctrl_n[62]}
N 93900 -820 93940 -820 {lab=ctrl_n[62]}
N 93940 -1320 94290 -1320 {lab=ctrl_n[62]}
N 94290 -1380 94290 -1320 {lab=ctrl_n[62]}
N 94400 -820 94440 -820 {lab=ctrl_n[62]}
N 94480 -820 94520 -820 {lab=ctrl_p[62]}
N 94440 -1320 94800 -1320 {lab=ctrl_n[62]}
N 94440 -1320 94440 -820 {lab=ctrl_n[62]}
N 94290 -1320 94440 -1320 {lab=ctrl_n[62]}
N 94240 -1350 94480 -1350 {lab=ctrl_p[62]}
N 94480 -1350 94480 -820 {lab=ctrl_p[62]}
N 94800 -1320 94800 -820 {lab=ctrl_n[62]}
N 94770 -820 94800 -820 {lab=ctrl_n[62]}
N 94460 -650 94460 -580 {lab=Source[62]}
N 94280 -650 94460 -650 {lab=Source[62]}
N 93690 -820 93730 -820 {lab=#net435}
N 93730 -820 93730 -460 {lab=#net435}
N 94000 -820 94040 -820 {lab=#net436}
N 94040 -820 94040 -460 {lab=#net436}
N 93730 -400 93730 -330 {lab=Vss}
N 94600 -330 94900 -330 {lab=Vss}
N 94900 -1080 94900 -330 {lab=Vss}
N 94900 -1080 96400 -1080 {lab=Vss}
N 94870 -1110 96370 -1110 {lab=1.2V}
N 94870 -1110 94870 -360 {lab=1.2V}
N 94040 -400 94040 -330 {lab=Vss}
N 93730 -330 94040 -330 {lab=Vss}
N 94690 -360 94870 -360 {lab=1.2V}
N 94320 -820 94360 -820 {lab=#net437}
N 94320 -820 94320 -460 {lab=#net437}
N 94190 -820 94230 -820 {lab=#net438}
N 94230 -820 94230 -460 {lab=#net438}
N 94320 -400 94320 -360 {lab=1.2V}
N 94230 -400 94230 -330 {lab=Vss}
N 94040 -330 94230 -330 {lab=Vss}
N 93810 -820 93860 -820 {lab=#net439}
N 93810 -820 93810 -460 {lab=#net439}
N 93810 -400 93810 -360 {lab=1.2V}
N 93810 -360 94320 -360 {lab=1.2V}
N 94560 -820 94600 -820 {lab=#net440}
N 94600 -820 94600 -460 {lab=#net440}
N 94690 -820 94730 -820 {lab=#net441}
N 94690 -820 94690 -460 {lab=#net441}
N 94690 -400 94690 -360 {lab=1.2V}
N 94320 -360 94690 -360 {lab=1.2V}
N 94600 -400 94600 -330 {lab=Vss}
N 94230 -330 94600 -330 {lab=Vss}
N 95190 -960 95190 -850 {lab=Gdrive}
N 95280 -960 95360 -960 {lab=Gdrive}
N 95360 -960 95360 -850 {lab=Gdrive}
N 95190 -790 95190 -700 {lab=Gate[63]}
N 95280 -700 95360 -700 {lab=Gate[63]}
N 95360 -790 95360 -700 {lab=Gate[63]}
N 95500 -790 95500 -650 {lab=Gate[63]}
N 95390 -650 95500 -650 {lab=Gate[63]}
N 95280 -700 95280 -650 {lab=Gate[63]}
N 95190 -700 95280 -700 {lab=Gate[63]}
N 95390 -650 95390 -570 {lab=Gate[63]}
N 95280 -650 95390 -650 {lab=Gate[63]}
N 95440 -820 95460 -820 {lab=ctrl_n[63]}
N 95690 -960 95690 -850 {lab=Ssense}
N 95780 -960 95860 -960 {lab=Ssense}
N 95860 -960 95860 -850 {lab=Ssense}
N 95690 -790 95690 -700 {lab=Source[63]}
N 95780 -700 95860 -700 {lab=Source[63]}
N 95860 -790 95860 -700 {lab=Source[63]}
N 95780 -700 95780 -650 {lab=Source[63]}
N 95690 -700 95780 -700 {lab=Source[63]}
N 96060 -960 96060 -850 {lab=Sforce}
N 96150 -960 96230 -960 {lab=Sforce}
N 96230 -960 96230 -850 {lab=Sforce}
N 96060 -790 96060 -700 {lab=Source[63]}
N 96150 -700 96230 -700 {lab=Source[63]}
N 96230 -790 96230 -700 {lab=Source[63]}
N 96150 -700 96150 -650 {lab=Source[63]}
N 96060 -700 96150 -700 {lab=Source[63]}
N 95960 -650 96150 -650 {lab=Source[63]}
N 96150 -1140 97650 -1140 {lab=Sforce}
N 96150 -1140 96150 -960 {lab=Sforce}
N 96060 -960 96150 -960 {lab=Sforce}
N 95780 -1170 97280 -1170 {lab=Ssense}
N 95780 -1170 95780 -960 {lab=Ssense}
N 95690 -960 95780 -960 {lab=Ssense}
N 95280 -1200 96780 -1200 {lab=Gdrive}
N 95280 -1200 95280 -960 {lab=Gdrive}
N 95190 -960 95280 -960 {lab=Gdrive}
N 95500 -1230 97000 -1230 {lab=Vcl}
N 95500 -1230 95500 -850 {lab=Vcl}
N 95740 -1380 95740 -1350 {lab=ctrl_p[63]}
N 95610 -1350 95740 -1350 {lab=ctrl_p[63]}
N 95110 -1350 95110 -820 {lab=ctrl_p[63]}
N 95110 -820 95150 -820 {lab=ctrl_p[63]}
N 95610 -820 95650 -820 {lab=ctrl_p[63]}
N 95610 -1350 95610 -820 {lab=ctrl_p[63]}
N 95110 -1350 95610 -1350 {lab=ctrl_p[63]}
N 95440 -1320 95440 -820 {lab=ctrl_n[63]}
N 95400 -820 95440 -820 {lab=ctrl_n[63]}
N 95440 -1320 95790 -1320 {lab=ctrl_n[63]}
N 95790 -1380 95790 -1320 {lab=ctrl_n[63]}
N 95900 -820 95940 -820 {lab=ctrl_n[63]}
N 95980 -820 96020 -820 {lab=ctrl_p[63]}
N 95940 -1320 96300 -1320 {lab=ctrl_n[63]}
N 95940 -1320 95940 -820 {lab=ctrl_n[63]}
N 95790 -1320 95940 -1320 {lab=ctrl_n[63]}
N 95740 -1350 95980 -1350 {lab=ctrl_p[63]}
N 95980 -1350 95980 -820 {lab=ctrl_p[63]}
N 96300 -1320 96300 -820 {lab=ctrl_n[63]}
N 96270 -820 96300 -820 {lab=ctrl_n[63]}
N 95960 -650 95960 -580 {lab=Source[63]}
N 95780 -650 95960 -650 {lab=Source[63]}
N 95190 -820 95230 -820 {lab=#net442}
N 95230 -820 95230 -460 {lab=#net442}
N 95500 -820 95540 -820 {lab=#net443}
N 95540 -820 95540 -460 {lab=#net443}
N 95230 -400 95230 -330 {lab=Vss}
N 96100 -330 96400 -330 {lab=Vss}
N 96400 -1080 96400 -330 {lab=Vss}
N 96400 -1080 97900 -1080 {lab=Vss}
N 96370 -1110 97870 -1110 {lab=1.2V}
N 96370 -1110 96370 -360 {lab=1.2V}
N 95540 -400 95540 -330 {lab=Vss}
N 95230 -330 95540 -330 {lab=Vss}
N 96190 -360 96370 -360 {lab=1.2V}
N 95820 -820 95860 -820 {lab=#net444}
N 95820 -820 95820 -460 {lab=#net444}
N 95690 -820 95730 -820 {lab=#net445}
N 95730 -820 95730 -460 {lab=#net445}
N 95820 -400 95820 -360 {lab=1.2V}
N 95730 -400 95730 -330 {lab=Vss}
N 95540 -330 95730 -330 {lab=Vss}
N 95310 -820 95360 -820 {lab=#net446}
N 95310 -820 95310 -460 {lab=#net446}
N 95310 -400 95310 -360 {lab=1.2V}
N 95310 -360 95820 -360 {lab=1.2V}
N 96060 -820 96100 -820 {lab=#net447}
N 96100 -820 96100 -460 {lab=#net447}
N 96190 -820 96230 -820 {lab=#net448}
N 96190 -820 96190 -460 {lab=#net448}
N 96190 -400 96190 -360 {lab=1.2V}
N 95820 -360 96190 -360 {lab=1.2V}
N 96100 -400 96100 -330 {lab=Vss}
N 95730 -330 96100 -330 {lab=Vss}
N 96690 -960 96690 -850 {lab=Gdrive}
N 96780 -960 96860 -960 {lab=Gdrive}
N 96860 -960 96860 -850 {lab=Gdrive}
N 96690 -790 96690 -700 {lab=Gate[64]}
N 96780 -700 96860 -700 {lab=Gate[64]}
N 96860 -790 96860 -700 {lab=Gate[64]}
N 97000 -790 97000 -650 {lab=Gate[64]}
N 96890 -650 97000 -650 {lab=Gate[64]}
N 96780 -700 96780 -650 {lab=Gate[64]}
N 96690 -700 96780 -700 {lab=Gate[64]}
N 96890 -650 96890 -570 {lab=Gate[64]}
N 96780 -650 96890 -650 {lab=Gate[64]}
N 96940 -820 96960 -820 {lab=ctrl_n[64]}
N 97190 -960 97190 -850 {lab=Ssense}
N 97280 -960 97360 -960 {lab=Ssense}
N 97360 -960 97360 -850 {lab=Ssense}
N 97190 -790 97190 -700 {lab=Source[64]}
N 97280 -700 97360 -700 {lab=Source[64]}
N 97360 -790 97360 -700 {lab=Source[64]}
N 97280 -700 97280 -650 {lab=Source[64]}
N 97190 -700 97280 -700 {lab=Source[64]}
N 97560 -960 97560 -850 {lab=Sforce}
N 97650 -960 97730 -960 {lab=Sforce}
N 97730 -960 97730 -850 {lab=Sforce}
N 97560 -790 97560 -700 {lab=Source[64]}
N 97650 -700 97730 -700 {lab=Source[64]}
N 97730 -790 97730 -700 {lab=Source[64]}
N 97650 -700 97650 -650 {lab=Source[64]}
N 97560 -700 97650 -700 {lab=Source[64]}
N 97460 -650 97650 -650 {lab=Source[64]}
N 97650 -1140 99150 -1140 {lab=Sforce}
N 97650 -1140 97650 -960 {lab=Sforce}
N 97560 -960 97650 -960 {lab=Sforce}
N 97280 -1170 98780 -1170 {lab=Ssense}
N 97280 -1170 97280 -960 {lab=Ssense}
N 97190 -960 97280 -960 {lab=Ssense}
N 96780 -1200 98280 -1200 {lab=Gdrive}
N 96780 -1200 96780 -960 {lab=Gdrive}
N 96690 -960 96780 -960 {lab=Gdrive}
N 97000 -1230 98500 -1230 {lab=Vcl}
N 97000 -1230 97000 -850 {lab=Vcl}
N 97240 -1380 97240 -1350 {lab=ctrl_p[64]}
N 97110 -1350 97240 -1350 {lab=ctrl_p[64]}
N 96610 -1350 96610 -820 {lab=ctrl_p[64]}
N 96610 -820 96650 -820 {lab=ctrl_p[64]}
N 97110 -820 97150 -820 {lab=ctrl_p[64]}
N 97110 -1350 97110 -820 {lab=ctrl_p[64]}
N 96610 -1350 97110 -1350 {lab=ctrl_p[64]}
N 96940 -1320 96940 -820 {lab=ctrl_n[64]}
N 96900 -820 96940 -820 {lab=ctrl_n[64]}
N 96940 -1320 97290 -1320 {lab=ctrl_n[64]}
N 97290 -1380 97290 -1320 {lab=ctrl_n[64]}
N 97400 -820 97440 -820 {lab=ctrl_n[64]}
N 97480 -820 97520 -820 {lab=ctrl_p[64]}
N 97440 -1320 97800 -1320 {lab=ctrl_n[64]}
N 97440 -1320 97440 -820 {lab=ctrl_n[64]}
N 97290 -1320 97440 -1320 {lab=ctrl_n[64]}
N 97240 -1350 97480 -1350 {lab=ctrl_p[64]}
N 97480 -1350 97480 -820 {lab=ctrl_p[64]}
N 97800 -1320 97800 -820 {lab=ctrl_n[64]}
N 97770 -820 97800 -820 {lab=ctrl_n[64]}
N 97460 -650 97460 -580 {lab=Source[64]}
N 97280 -650 97460 -650 {lab=Source[64]}
N 96690 -820 96730 -820 {lab=#net449}
N 96730 -820 96730 -460 {lab=#net449}
N 97000 -820 97040 -820 {lab=#net450}
N 97040 -820 97040 -460 {lab=#net450}
N 96730 -400 96730 -330 {lab=Vss}
N 97600 -330 97900 -330 {lab=Vss}
N 97900 -1080 97900 -330 {lab=Vss}
N 97900 -1080 99400 -1080 {lab=Vss}
N 97870 -1110 99370 -1110 {lab=1.2V}
N 97870 -1110 97870 -360 {lab=1.2V}
N 97040 -400 97040 -330 {lab=Vss}
N 96730 -330 97040 -330 {lab=Vss}
N 97690 -360 97870 -360 {lab=1.2V}
N 97320 -820 97360 -820 {lab=#net451}
N 97320 -820 97320 -460 {lab=#net451}
N 97190 -820 97230 -820 {lab=#net452}
N 97230 -820 97230 -460 {lab=#net452}
N 97320 -400 97320 -360 {lab=1.2V}
N 97230 -400 97230 -330 {lab=Vss}
N 97040 -330 97230 -330 {lab=Vss}
N 96810 -820 96860 -820 {lab=#net453}
N 96810 -820 96810 -460 {lab=#net453}
N 96810 -400 96810 -360 {lab=1.2V}
N 96810 -360 97320 -360 {lab=1.2V}
N 97560 -820 97600 -820 {lab=#net454}
N 97600 -820 97600 -460 {lab=#net454}
N 97690 -820 97730 -820 {lab=#net455}
N 97690 -820 97690 -460 {lab=#net455}
N 97690 -400 97690 -360 {lab=1.2V}
N 97320 -360 97690 -360 {lab=1.2V}
N 97600 -400 97600 -330 {lab=Vss}
N 97230 -330 97600 -330 {lab=Vss}
N 98190 -960 98190 -850 {lab=Gdrive}
N 98280 -960 98360 -960 {lab=Gdrive}
N 98360 -960 98360 -850 {lab=Gdrive}
N 98190 -790 98190 -700 {lab=Gate[65]}
N 98280 -700 98360 -700 {lab=Gate[65]}
N 98360 -790 98360 -700 {lab=Gate[65]}
N 98500 -790 98500 -650 {lab=Gate[65]}
N 98390 -650 98500 -650 {lab=Gate[65]}
N 98280 -700 98280 -650 {lab=Gate[65]}
N 98190 -700 98280 -700 {lab=Gate[65]}
N 98390 -650 98390 -570 {lab=Gate[65]}
N 98280 -650 98390 -650 {lab=Gate[65]}
N 98440 -820 98460 -820 {lab=ctrl_n[65]}
N 98690 -960 98690 -850 {lab=Ssense}
N 98780 -960 98860 -960 {lab=Ssense}
N 98860 -960 98860 -850 {lab=Ssense}
N 98690 -790 98690 -700 {lab=Source[65]}
N 98780 -700 98860 -700 {lab=Source[65]}
N 98860 -790 98860 -700 {lab=Source[65]}
N 98780 -700 98780 -650 {lab=Source[65]}
N 98690 -700 98780 -700 {lab=Source[65]}
N 99060 -960 99060 -850 {lab=Sforce}
N 99150 -960 99230 -960 {lab=Sforce}
N 99230 -960 99230 -850 {lab=Sforce}
N 99060 -790 99060 -700 {lab=Source[65]}
N 99150 -700 99230 -700 {lab=Source[65]}
N 99230 -790 99230 -700 {lab=Source[65]}
N 99150 -700 99150 -650 {lab=Source[65]}
N 99060 -700 99150 -700 {lab=Source[65]}
N 98960 -650 99150 -650 {lab=Source[65]}
N 99150 -1140 100650 -1140 {lab=Sforce}
N 99150 -1140 99150 -960 {lab=Sforce}
N 99060 -960 99150 -960 {lab=Sforce}
N 98780 -1170 100280 -1170 {lab=Ssense}
N 98780 -1170 98780 -960 {lab=Ssense}
N 98690 -960 98780 -960 {lab=Ssense}
N 98280 -1200 99780 -1200 {lab=Gdrive}
N 98280 -1200 98280 -960 {lab=Gdrive}
N 98190 -960 98280 -960 {lab=Gdrive}
N 98500 -1230 100000 -1230 {lab=Vcl}
N 98500 -1230 98500 -850 {lab=Vcl}
N 98740 -1380 98740 -1350 {lab=ctrl_p[65]}
N 98610 -1350 98740 -1350 {lab=ctrl_p[65]}
N 98110 -1350 98110 -820 {lab=ctrl_p[65]}
N 98110 -820 98150 -820 {lab=ctrl_p[65]}
N 98610 -820 98650 -820 {lab=ctrl_p[65]}
N 98610 -1350 98610 -820 {lab=ctrl_p[65]}
N 98110 -1350 98610 -1350 {lab=ctrl_p[65]}
N 98440 -1320 98440 -820 {lab=ctrl_n[65]}
N 98400 -820 98440 -820 {lab=ctrl_n[65]}
N 98440 -1320 98790 -1320 {lab=ctrl_n[65]}
N 98790 -1380 98790 -1320 {lab=ctrl_n[65]}
N 98900 -820 98940 -820 {lab=ctrl_n[65]}
N 98980 -820 99020 -820 {lab=ctrl_p[65]}
N 98940 -1320 99300 -1320 {lab=ctrl_n[65]}
N 98940 -1320 98940 -820 {lab=ctrl_n[65]}
N 98790 -1320 98940 -1320 {lab=ctrl_n[65]}
N 98740 -1350 98980 -1350 {lab=ctrl_p[65]}
N 98980 -1350 98980 -820 {lab=ctrl_p[65]}
N 99300 -1320 99300 -820 {lab=ctrl_n[65]}
N 99270 -820 99300 -820 {lab=ctrl_n[65]}
N 98960 -650 98960 -580 {lab=Source[65]}
N 98780 -650 98960 -650 {lab=Source[65]}
N 98190 -820 98230 -820 {lab=#net456}
N 98230 -820 98230 -460 {lab=#net456}
N 98500 -820 98540 -820 {lab=#net457}
N 98540 -820 98540 -460 {lab=#net457}
N 98230 -400 98230 -330 {lab=Vss}
N 99100 -330 99400 -330 {lab=Vss}
N 99400 -1080 99400 -330 {lab=Vss}
N 99400 -1080 100900 -1080 {lab=Vss}
N 99370 -1110 100870 -1110 {lab=1.2V}
N 99370 -1110 99370 -360 {lab=1.2V}
N 98540 -400 98540 -330 {lab=Vss}
N 98230 -330 98540 -330 {lab=Vss}
N 99190 -360 99370 -360 {lab=1.2V}
N 98820 -820 98860 -820 {lab=#net458}
N 98820 -820 98820 -460 {lab=#net458}
N 98690 -820 98730 -820 {lab=#net459}
N 98730 -820 98730 -460 {lab=#net459}
N 98820 -400 98820 -360 {lab=1.2V}
N 98730 -400 98730 -330 {lab=Vss}
N 98540 -330 98730 -330 {lab=Vss}
N 98310 -820 98360 -820 {lab=#net460}
N 98310 -820 98310 -460 {lab=#net460}
N 98310 -400 98310 -360 {lab=1.2V}
N 98310 -360 98820 -360 {lab=1.2V}
N 99060 -820 99100 -820 {lab=#net461}
N 99100 -820 99100 -460 {lab=#net461}
N 99190 -820 99230 -820 {lab=#net462}
N 99190 -820 99190 -460 {lab=#net462}
N 99190 -400 99190 -360 {lab=1.2V}
N 98820 -360 99190 -360 {lab=1.2V}
N 99100 -400 99100 -330 {lab=Vss}
N 98730 -330 99100 -330 {lab=Vss}
N 99690 -960 99690 -850 {lab=Gdrive}
N 99780 -960 99860 -960 {lab=Gdrive}
N 99860 -960 99860 -850 {lab=Gdrive}
N 99690 -790 99690 -700 {lab=Gate[66]}
N 99780 -700 99860 -700 {lab=Gate[66]}
N 99860 -790 99860 -700 {lab=Gate[66]}
N 100000 -790 100000 -650 {lab=Gate[66]}
N 99890 -650 100000 -650 {lab=Gate[66]}
N 99780 -700 99780 -650 {lab=Gate[66]}
N 99690 -700 99780 -700 {lab=Gate[66]}
N 99890 -650 99890 -570 {lab=Gate[66]}
N 99780 -650 99890 -650 {lab=Gate[66]}
N 99940 -820 99960 -820 {lab=ctrl_n[66]}
N 100190 -960 100190 -850 {lab=Ssense}
N 100280 -960 100360 -960 {lab=Ssense}
N 100360 -960 100360 -850 {lab=Ssense}
N 100190 -790 100190 -700 {lab=Source[66]}
N 100280 -700 100360 -700 {lab=Source[66]}
N 100360 -790 100360 -700 {lab=Source[66]}
N 100280 -700 100280 -650 {lab=Source[66]}
N 100190 -700 100280 -700 {lab=Source[66]}
N 100560 -960 100560 -850 {lab=Sforce}
N 100650 -960 100730 -960 {lab=Sforce}
N 100730 -960 100730 -850 {lab=Sforce}
N 100560 -790 100560 -700 {lab=Source[66]}
N 100650 -700 100730 -700 {lab=Source[66]}
N 100730 -790 100730 -700 {lab=Source[66]}
N 100650 -700 100650 -650 {lab=Source[66]}
N 100560 -700 100650 -700 {lab=Source[66]}
N 100460 -650 100650 -650 {lab=Source[66]}
N 100650 -1140 102150 -1140 {lab=Sforce}
N 100650 -1140 100650 -960 {lab=Sforce}
N 100560 -960 100650 -960 {lab=Sforce}
N 100280 -1170 101780 -1170 {lab=Ssense}
N 100280 -1170 100280 -960 {lab=Ssense}
N 100190 -960 100280 -960 {lab=Ssense}
N 99780 -1200 101280 -1200 {lab=Gdrive}
N 99780 -1200 99780 -960 {lab=Gdrive}
N 99690 -960 99780 -960 {lab=Gdrive}
N 100000 -1230 101500 -1230 {lab=Vcl}
N 100000 -1230 100000 -850 {lab=Vcl}
N 100240 -1380 100240 -1350 {lab=ctrl_p[66]}
N 100110 -1350 100240 -1350 {lab=ctrl_p[66]}
N 99610 -1350 99610 -820 {lab=ctrl_p[66]}
N 99610 -820 99650 -820 {lab=ctrl_p[66]}
N 100110 -820 100150 -820 {lab=ctrl_p[66]}
N 100110 -1350 100110 -820 {lab=ctrl_p[66]}
N 99610 -1350 100110 -1350 {lab=ctrl_p[66]}
N 99940 -1320 99940 -820 {lab=ctrl_n[66]}
N 99900 -820 99940 -820 {lab=ctrl_n[66]}
N 99940 -1320 100290 -1320 {lab=ctrl_n[66]}
N 100290 -1380 100290 -1320 {lab=ctrl_n[66]}
N 100400 -820 100440 -820 {lab=ctrl_n[66]}
N 100480 -820 100520 -820 {lab=ctrl_p[66]}
N 100440 -1320 100800 -1320 {lab=ctrl_n[66]}
N 100440 -1320 100440 -820 {lab=ctrl_n[66]}
N 100290 -1320 100440 -1320 {lab=ctrl_n[66]}
N 100240 -1350 100480 -1350 {lab=ctrl_p[66]}
N 100480 -1350 100480 -820 {lab=ctrl_p[66]}
N 100800 -1320 100800 -820 {lab=ctrl_n[66]}
N 100770 -820 100800 -820 {lab=ctrl_n[66]}
N 100460 -650 100460 -580 {lab=Source[66]}
N 100280 -650 100460 -650 {lab=Source[66]}
N 99690 -820 99730 -820 {lab=#net463}
N 99730 -820 99730 -460 {lab=#net463}
N 100000 -820 100040 -820 {lab=#net464}
N 100040 -820 100040 -460 {lab=#net464}
N 99730 -400 99730 -330 {lab=Vss}
N 100600 -330 100900 -330 {lab=Vss}
N 100900 -1080 100900 -330 {lab=Vss}
N 100900 -1080 102400 -1080 {lab=Vss}
N 100870 -1110 102370 -1110 {lab=1.2V}
N 100870 -1110 100870 -360 {lab=1.2V}
N 100040 -400 100040 -330 {lab=Vss}
N 99730 -330 100040 -330 {lab=Vss}
N 100690 -360 100870 -360 {lab=1.2V}
N 100320 -820 100360 -820 {lab=#net465}
N 100320 -820 100320 -460 {lab=#net465}
N 100190 -820 100230 -820 {lab=#net466}
N 100230 -820 100230 -460 {lab=#net466}
N 100320 -400 100320 -360 {lab=1.2V}
N 100230 -400 100230 -330 {lab=Vss}
N 100040 -330 100230 -330 {lab=Vss}
N 99810 -820 99860 -820 {lab=#net467}
N 99810 -820 99810 -460 {lab=#net467}
N 99810 -400 99810 -360 {lab=1.2V}
N 99810 -360 100320 -360 {lab=1.2V}
N 100560 -820 100600 -820 {lab=#net468}
N 100600 -820 100600 -460 {lab=#net468}
N 100690 -820 100730 -820 {lab=#net469}
N 100690 -820 100690 -460 {lab=#net469}
N 100690 -400 100690 -360 {lab=1.2V}
N 100320 -360 100690 -360 {lab=1.2V}
N 100600 -400 100600 -330 {lab=Vss}
N 100230 -330 100600 -330 {lab=Vss}
N 101190 -960 101190 -850 {lab=Gdrive}
N 101280 -960 101360 -960 {lab=Gdrive}
N 101360 -960 101360 -850 {lab=Gdrive}
N 101190 -790 101190 -700 {lab=Gate[67]}
N 101280 -700 101360 -700 {lab=Gate[67]}
N 101360 -790 101360 -700 {lab=Gate[67]}
N 101500 -790 101500 -650 {lab=Gate[67]}
N 101390 -650 101500 -650 {lab=Gate[67]}
N 101280 -700 101280 -650 {lab=Gate[67]}
N 101190 -700 101280 -700 {lab=Gate[67]}
N 101390 -650 101390 -570 {lab=Gate[67]}
N 101280 -650 101390 -650 {lab=Gate[67]}
N 101440 -820 101460 -820 {lab=ctrl_n[67]}
N 101690 -960 101690 -850 {lab=Ssense}
N 101780 -960 101860 -960 {lab=Ssense}
N 101860 -960 101860 -850 {lab=Ssense}
N 101690 -790 101690 -700 {lab=Source[67]}
N 101780 -700 101860 -700 {lab=Source[67]}
N 101860 -790 101860 -700 {lab=Source[67]}
N 101780 -700 101780 -650 {lab=Source[67]}
N 101690 -700 101780 -700 {lab=Source[67]}
N 102060 -960 102060 -850 {lab=Sforce}
N 102150 -960 102230 -960 {lab=Sforce}
N 102230 -960 102230 -850 {lab=Sforce}
N 102060 -790 102060 -700 {lab=Source[67]}
N 102150 -700 102230 -700 {lab=Source[67]}
N 102230 -790 102230 -700 {lab=Source[67]}
N 102150 -700 102150 -650 {lab=Source[67]}
N 102060 -700 102150 -700 {lab=Source[67]}
N 101960 -650 102150 -650 {lab=Source[67]}
N 102150 -1140 103650 -1140 {lab=Sforce}
N 102150 -1140 102150 -960 {lab=Sforce}
N 102060 -960 102150 -960 {lab=Sforce}
N 101780 -1170 103280 -1170 {lab=Ssense}
N 101780 -1170 101780 -960 {lab=Ssense}
N 101690 -960 101780 -960 {lab=Ssense}
N 101280 -1200 102780 -1200 {lab=Gdrive}
N 101280 -1200 101280 -960 {lab=Gdrive}
N 101190 -960 101280 -960 {lab=Gdrive}
N 101500 -1230 103000 -1230 {lab=Vcl}
N 101500 -1230 101500 -850 {lab=Vcl}
N 101740 -1380 101740 -1350 {lab=ctrl_p[67]}
N 101610 -1350 101740 -1350 {lab=ctrl_p[67]}
N 101110 -1350 101110 -820 {lab=ctrl_p[67]}
N 101110 -820 101150 -820 {lab=ctrl_p[67]}
N 101610 -820 101650 -820 {lab=ctrl_p[67]}
N 101610 -1350 101610 -820 {lab=ctrl_p[67]}
N 101110 -1350 101610 -1350 {lab=ctrl_p[67]}
N 101440 -1320 101440 -820 {lab=ctrl_n[67]}
N 101400 -820 101440 -820 {lab=ctrl_n[67]}
N 101440 -1320 101790 -1320 {lab=ctrl_n[67]}
N 101790 -1380 101790 -1320 {lab=ctrl_n[67]}
N 101900 -820 101940 -820 {lab=ctrl_n[67]}
N 101980 -820 102020 -820 {lab=ctrl_p[67]}
N 101940 -1320 102300 -1320 {lab=ctrl_n[67]}
N 101940 -1320 101940 -820 {lab=ctrl_n[67]}
N 101790 -1320 101940 -1320 {lab=ctrl_n[67]}
N 101740 -1350 101980 -1350 {lab=ctrl_p[67]}
N 101980 -1350 101980 -820 {lab=ctrl_p[67]}
N 102300 -1320 102300 -820 {lab=ctrl_n[67]}
N 102270 -820 102300 -820 {lab=ctrl_n[67]}
N 101960 -650 101960 -580 {lab=Source[67]}
N 101780 -650 101960 -650 {lab=Source[67]}
N 101190 -820 101230 -820 {lab=#net470}
N 101230 -820 101230 -460 {lab=#net470}
N 101500 -820 101540 -820 {lab=#net471}
N 101540 -820 101540 -460 {lab=#net471}
N 101230 -400 101230 -330 {lab=Vss}
N 102100 -330 102400 -330 {lab=Vss}
N 102400 -1080 102400 -330 {lab=Vss}
N 102400 -1080 103900 -1080 {lab=Vss}
N 102370 -1110 103870 -1110 {lab=1.2V}
N 102370 -1110 102370 -360 {lab=1.2V}
N 101540 -400 101540 -330 {lab=Vss}
N 101230 -330 101540 -330 {lab=Vss}
N 102190 -360 102370 -360 {lab=1.2V}
N 101820 -820 101860 -820 {lab=#net472}
N 101820 -820 101820 -460 {lab=#net472}
N 101690 -820 101730 -820 {lab=#net473}
N 101730 -820 101730 -460 {lab=#net473}
N 101820 -400 101820 -360 {lab=1.2V}
N 101730 -400 101730 -330 {lab=Vss}
N 101540 -330 101730 -330 {lab=Vss}
N 101310 -820 101360 -820 {lab=#net474}
N 101310 -820 101310 -460 {lab=#net474}
N 101310 -400 101310 -360 {lab=1.2V}
N 101310 -360 101820 -360 {lab=1.2V}
N 102060 -820 102100 -820 {lab=#net475}
N 102100 -820 102100 -460 {lab=#net475}
N 102190 -820 102230 -820 {lab=#net476}
N 102190 -820 102190 -460 {lab=#net476}
N 102190 -400 102190 -360 {lab=1.2V}
N 101820 -360 102190 -360 {lab=1.2V}
N 102100 -400 102100 -330 {lab=Vss}
N 101730 -330 102100 -330 {lab=Vss}
N 102690 -960 102690 -850 {lab=Gdrive}
N 102780 -960 102860 -960 {lab=Gdrive}
N 102860 -960 102860 -850 {lab=Gdrive}
N 102690 -790 102690 -700 {lab=Gate[68]}
N 102780 -700 102860 -700 {lab=Gate[68]}
N 102860 -790 102860 -700 {lab=Gate[68]}
N 103000 -790 103000 -650 {lab=Gate[68]}
N 102890 -650 103000 -650 {lab=Gate[68]}
N 102780 -700 102780 -650 {lab=Gate[68]}
N 102690 -700 102780 -700 {lab=Gate[68]}
N 102890 -650 102890 -570 {lab=Gate[68]}
N 102780 -650 102890 -650 {lab=Gate[68]}
N 102940 -820 102960 -820 {lab=ctrl_n[68]}
N 103190 -960 103190 -850 {lab=Ssense}
N 103280 -960 103360 -960 {lab=Ssense}
N 103360 -960 103360 -850 {lab=Ssense}
N 103190 -790 103190 -700 {lab=Source[68]}
N 103280 -700 103360 -700 {lab=Source[68]}
N 103360 -790 103360 -700 {lab=Source[68]}
N 103280 -700 103280 -650 {lab=Source[68]}
N 103190 -700 103280 -700 {lab=Source[68]}
N 103560 -960 103560 -850 {lab=Sforce}
N 103650 -960 103730 -960 {lab=Sforce}
N 103730 -960 103730 -850 {lab=Sforce}
N 103560 -790 103560 -700 {lab=Source[68]}
N 103650 -700 103730 -700 {lab=Source[68]}
N 103730 -790 103730 -700 {lab=Source[68]}
N 103650 -700 103650 -650 {lab=Source[68]}
N 103560 -700 103650 -700 {lab=Source[68]}
N 103460 -650 103650 -650 {lab=Source[68]}
N 103650 -1140 105150 -1140 {lab=Sforce}
N 103650 -1140 103650 -960 {lab=Sforce}
N 103560 -960 103650 -960 {lab=Sforce}
N 103280 -1170 104780 -1170 {lab=Ssense}
N 103280 -1170 103280 -960 {lab=Ssense}
N 103190 -960 103280 -960 {lab=Ssense}
N 102780 -1200 104280 -1200 {lab=Gdrive}
N 102780 -1200 102780 -960 {lab=Gdrive}
N 102690 -960 102780 -960 {lab=Gdrive}
N 103000 -1230 104500 -1230 {lab=Vcl}
N 103000 -1230 103000 -850 {lab=Vcl}
N 103240 -1380 103240 -1350 {lab=ctrl_p[68]}
N 103110 -1350 103240 -1350 {lab=ctrl_p[68]}
N 102610 -1350 102610 -820 {lab=ctrl_p[68]}
N 102610 -820 102650 -820 {lab=ctrl_p[68]}
N 103110 -820 103150 -820 {lab=ctrl_p[68]}
N 103110 -1350 103110 -820 {lab=ctrl_p[68]}
N 102610 -1350 103110 -1350 {lab=ctrl_p[68]}
N 102940 -1320 102940 -820 {lab=ctrl_n[68]}
N 102900 -820 102940 -820 {lab=ctrl_n[68]}
N 102940 -1320 103290 -1320 {lab=ctrl_n[68]}
N 103290 -1380 103290 -1320 {lab=ctrl_n[68]}
N 103400 -820 103440 -820 {lab=ctrl_n[68]}
N 103480 -820 103520 -820 {lab=ctrl_p[68]}
N 103440 -1320 103800 -1320 {lab=ctrl_n[68]}
N 103440 -1320 103440 -820 {lab=ctrl_n[68]}
N 103290 -1320 103440 -1320 {lab=ctrl_n[68]}
N 103240 -1350 103480 -1350 {lab=ctrl_p[68]}
N 103480 -1350 103480 -820 {lab=ctrl_p[68]}
N 103800 -1320 103800 -820 {lab=ctrl_n[68]}
N 103770 -820 103800 -820 {lab=ctrl_n[68]}
N 103460 -650 103460 -580 {lab=Source[68]}
N 103280 -650 103460 -650 {lab=Source[68]}
N 102690 -820 102730 -820 {lab=#net477}
N 102730 -820 102730 -460 {lab=#net477}
N 103000 -820 103040 -820 {lab=#net478}
N 103040 -820 103040 -460 {lab=#net478}
N 102730 -400 102730 -330 {lab=Vss}
N 103600 -330 103900 -330 {lab=Vss}
N 103900 -1080 103900 -330 {lab=Vss}
N 103900 -1080 105400 -1080 {lab=Vss}
N 103870 -1110 105370 -1110 {lab=1.2V}
N 103870 -1110 103870 -360 {lab=1.2V}
N 103040 -400 103040 -330 {lab=Vss}
N 102730 -330 103040 -330 {lab=Vss}
N 103690 -360 103870 -360 {lab=1.2V}
N 103320 -820 103360 -820 {lab=#net479}
N 103320 -820 103320 -460 {lab=#net479}
N 103190 -820 103230 -820 {lab=#net480}
N 103230 -820 103230 -460 {lab=#net480}
N 103320 -400 103320 -360 {lab=1.2V}
N 103230 -400 103230 -330 {lab=Vss}
N 103040 -330 103230 -330 {lab=Vss}
N 102810 -820 102860 -820 {lab=#net481}
N 102810 -820 102810 -460 {lab=#net481}
N 102810 -400 102810 -360 {lab=1.2V}
N 102810 -360 103320 -360 {lab=1.2V}
N 103560 -820 103600 -820 {lab=#net482}
N 103600 -820 103600 -460 {lab=#net482}
N 103690 -820 103730 -820 {lab=#net483}
N 103690 -820 103690 -460 {lab=#net483}
N 103690 -400 103690 -360 {lab=1.2V}
N 103320 -360 103690 -360 {lab=1.2V}
N 103600 -400 103600 -330 {lab=Vss}
N 103230 -330 103600 -330 {lab=Vss}
N 104190 -960 104190 -850 {lab=Gdrive}
N 104280 -960 104360 -960 {lab=Gdrive}
N 104360 -960 104360 -850 {lab=Gdrive}
N 104190 -790 104190 -700 {lab=Gate[69]}
N 104280 -700 104360 -700 {lab=Gate[69]}
N 104360 -790 104360 -700 {lab=Gate[69]}
N 104500 -790 104500 -650 {lab=Gate[69]}
N 104390 -650 104500 -650 {lab=Gate[69]}
N 104280 -700 104280 -650 {lab=Gate[69]}
N 104190 -700 104280 -700 {lab=Gate[69]}
N 104390 -650 104390 -570 {lab=Gate[69]}
N 104280 -650 104390 -650 {lab=Gate[69]}
N 104440 -820 104460 -820 {lab=ctrl_n[69]}
N 104690 -960 104690 -850 {lab=Ssense}
N 104780 -960 104860 -960 {lab=Ssense}
N 104860 -960 104860 -850 {lab=Ssense}
N 104690 -790 104690 -700 {lab=Source[69]}
N 104780 -700 104860 -700 {lab=Source[69]}
N 104860 -790 104860 -700 {lab=Source[69]}
N 104780 -700 104780 -650 {lab=Source[69]}
N 104690 -700 104780 -700 {lab=Source[69]}
N 105060 -960 105060 -850 {lab=Sforce}
N 105150 -960 105230 -960 {lab=Sforce}
N 105230 -960 105230 -850 {lab=Sforce}
N 105060 -790 105060 -700 {lab=Source[69]}
N 105150 -700 105230 -700 {lab=Source[69]}
N 105230 -790 105230 -700 {lab=Source[69]}
N 105150 -700 105150 -650 {lab=Source[69]}
N 105060 -700 105150 -700 {lab=Source[69]}
N 104960 -650 105150 -650 {lab=Source[69]}
N 105150 -1140 106650 -1140 {lab=Sforce}
N 105150 -1140 105150 -960 {lab=Sforce}
N 105060 -960 105150 -960 {lab=Sforce}
N 104780 -1170 106280 -1170 {lab=Ssense}
N 104780 -1170 104780 -960 {lab=Ssense}
N 104690 -960 104780 -960 {lab=Ssense}
N 104280 -1200 105780 -1200 {lab=Gdrive}
N 104280 -1200 104280 -960 {lab=Gdrive}
N 104190 -960 104280 -960 {lab=Gdrive}
N 104500 -1230 106000 -1230 {lab=Vcl}
N 104500 -1230 104500 -850 {lab=Vcl}
N 104740 -1380 104740 -1350 {lab=ctrl_p[69]}
N 104610 -1350 104740 -1350 {lab=ctrl_p[69]}
N 104110 -1350 104110 -820 {lab=ctrl_p[69]}
N 104110 -820 104150 -820 {lab=ctrl_p[69]}
N 104610 -820 104650 -820 {lab=ctrl_p[69]}
N 104610 -1350 104610 -820 {lab=ctrl_p[69]}
N 104110 -1350 104610 -1350 {lab=ctrl_p[69]}
N 104440 -1320 104440 -820 {lab=ctrl_n[69]}
N 104400 -820 104440 -820 {lab=ctrl_n[69]}
N 104440 -1320 104790 -1320 {lab=ctrl_n[69]}
N 104790 -1380 104790 -1320 {lab=ctrl_n[69]}
N 104900 -820 104940 -820 {lab=ctrl_n[69]}
N 104980 -820 105020 -820 {lab=ctrl_p[69]}
N 104940 -1320 105300 -1320 {lab=ctrl_n[69]}
N 104940 -1320 104940 -820 {lab=ctrl_n[69]}
N 104790 -1320 104940 -1320 {lab=ctrl_n[69]}
N 104740 -1350 104980 -1350 {lab=ctrl_p[69]}
N 104980 -1350 104980 -820 {lab=ctrl_p[69]}
N 105300 -1320 105300 -820 {lab=ctrl_n[69]}
N 105270 -820 105300 -820 {lab=ctrl_n[69]}
N 104960 -650 104960 -580 {lab=Source[69]}
N 104780 -650 104960 -650 {lab=Source[69]}
N 104190 -820 104230 -820 {lab=#net484}
N 104230 -820 104230 -460 {lab=#net484}
N 104500 -820 104540 -820 {lab=#net485}
N 104540 -820 104540 -460 {lab=#net485}
N 104230 -400 104230 -330 {lab=Vss}
N 105100 -330 105400 -330 {lab=Vss}
N 105400 -1080 105400 -330 {lab=Vss}
N 105400 -1080 106900 -1080 {lab=Vss}
N 105370 -1110 106870 -1110 {lab=1.2V}
N 105370 -1110 105370 -360 {lab=1.2V}
N 104540 -400 104540 -330 {lab=Vss}
N 104230 -330 104540 -330 {lab=Vss}
N 105190 -360 105370 -360 {lab=1.2V}
N 104820 -820 104860 -820 {lab=#net486}
N 104820 -820 104820 -460 {lab=#net486}
N 104690 -820 104730 -820 {lab=#net487}
N 104730 -820 104730 -460 {lab=#net487}
N 104820 -400 104820 -360 {lab=1.2V}
N 104730 -400 104730 -330 {lab=Vss}
N 104540 -330 104730 -330 {lab=Vss}
N 104310 -820 104360 -820 {lab=#net488}
N 104310 -820 104310 -460 {lab=#net488}
N 104310 -400 104310 -360 {lab=1.2V}
N 104310 -360 104820 -360 {lab=1.2V}
N 105060 -820 105100 -820 {lab=#net489}
N 105100 -820 105100 -460 {lab=#net489}
N 105190 -820 105230 -820 {lab=#net490}
N 105190 -820 105190 -460 {lab=#net490}
N 105190 -400 105190 -360 {lab=1.2V}
N 104820 -360 105190 -360 {lab=1.2V}
N 105100 -400 105100 -330 {lab=Vss}
N 104730 -330 105100 -330 {lab=Vss}
N 105690 -960 105690 -850 {lab=Gdrive}
N 105780 -960 105860 -960 {lab=Gdrive}
N 105860 -960 105860 -850 {lab=Gdrive}
N 105690 -790 105690 -700 {lab=Gate[70]}
N 105780 -700 105860 -700 {lab=Gate[70]}
N 105860 -790 105860 -700 {lab=Gate[70]}
N 106000 -790 106000 -650 {lab=Gate[70]}
N 105890 -650 106000 -650 {lab=Gate[70]}
N 105780 -700 105780 -650 {lab=Gate[70]}
N 105690 -700 105780 -700 {lab=Gate[70]}
N 105890 -650 105890 -570 {lab=Gate[70]}
N 105780 -650 105890 -650 {lab=Gate[70]}
N 105940 -820 105960 -820 {lab=ctrl_n[70]}
N 106190 -960 106190 -850 {lab=Ssense}
N 106280 -960 106360 -960 {lab=Ssense}
N 106360 -960 106360 -850 {lab=Ssense}
N 106190 -790 106190 -700 {lab=Source[70]}
N 106280 -700 106360 -700 {lab=Source[70]}
N 106360 -790 106360 -700 {lab=Source[70]}
N 106280 -700 106280 -650 {lab=Source[70]}
N 106190 -700 106280 -700 {lab=Source[70]}
N 106560 -960 106560 -850 {lab=Sforce}
N 106650 -960 106730 -960 {lab=Sforce}
N 106730 -960 106730 -850 {lab=Sforce}
N 106560 -790 106560 -700 {lab=Source[70]}
N 106650 -700 106730 -700 {lab=Source[70]}
N 106730 -790 106730 -700 {lab=Source[70]}
N 106650 -700 106650 -650 {lab=Source[70]}
N 106560 -700 106650 -700 {lab=Source[70]}
N 106460 -650 106650 -650 {lab=Source[70]}
N 106650 -1140 108150 -1140 {lab=Sforce}
N 106650 -1140 106650 -960 {lab=Sforce}
N 106560 -960 106650 -960 {lab=Sforce}
N 106280 -1170 107780 -1170 {lab=Ssense}
N 106280 -1170 106280 -960 {lab=Ssense}
N 106190 -960 106280 -960 {lab=Ssense}
N 105780 -1200 107280 -1200 {lab=Gdrive}
N 105780 -1200 105780 -960 {lab=Gdrive}
N 105690 -960 105780 -960 {lab=Gdrive}
N 106000 -1230 107500 -1230 {lab=Vcl}
N 106000 -1230 106000 -850 {lab=Vcl}
N 106240 -1380 106240 -1350 {lab=ctrl_p[70]}
N 106110 -1350 106240 -1350 {lab=ctrl_p[70]}
N 105610 -1350 105610 -820 {lab=ctrl_p[70]}
N 105610 -820 105650 -820 {lab=ctrl_p[70]}
N 106110 -820 106150 -820 {lab=ctrl_p[70]}
N 106110 -1350 106110 -820 {lab=ctrl_p[70]}
N 105610 -1350 106110 -1350 {lab=ctrl_p[70]}
N 105940 -1320 105940 -820 {lab=ctrl_n[70]}
N 105900 -820 105940 -820 {lab=ctrl_n[70]}
N 105940 -1320 106290 -1320 {lab=ctrl_n[70]}
N 106290 -1380 106290 -1320 {lab=ctrl_n[70]}
N 106400 -820 106440 -820 {lab=ctrl_n[70]}
N 106480 -820 106520 -820 {lab=ctrl_p[70]}
N 106440 -1320 106800 -1320 {lab=ctrl_n[70]}
N 106440 -1320 106440 -820 {lab=ctrl_n[70]}
N 106290 -1320 106440 -1320 {lab=ctrl_n[70]}
N 106240 -1350 106480 -1350 {lab=ctrl_p[70]}
N 106480 -1350 106480 -820 {lab=ctrl_p[70]}
N 106800 -1320 106800 -820 {lab=ctrl_n[70]}
N 106770 -820 106800 -820 {lab=ctrl_n[70]}
N 106460 -650 106460 -580 {lab=Source[70]}
N 106280 -650 106460 -650 {lab=Source[70]}
N 105690 -820 105730 -820 {lab=#net491}
N 105730 -820 105730 -460 {lab=#net491}
N 106000 -820 106040 -820 {lab=#net492}
N 106040 -820 106040 -460 {lab=#net492}
N 105730 -400 105730 -330 {lab=Vss}
N 106600 -330 106900 -330 {lab=Vss}
N 106900 -1080 106900 -330 {lab=Vss}
N 106900 -1080 108400 -1080 {lab=Vss}
N 106870 -1110 108370 -1110 {lab=1.2V}
N 106870 -1110 106870 -360 {lab=1.2V}
N 106040 -400 106040 -330 {lab=Vss}
N 105730 -330 106040 -330 {lab=Vss}
N 106690 -360 106870 -360 {lab=1.2V}
N 106320 -820 106360 -820 {lab=#net493}
N 106320 -820 106320 -460 {lab=#net493}
N 106190 -820 106230 -820 {lab=#net494}
N 106230 -820 106230 -460 {lab=#net494}
N 106320 -400 106320 -360 {lab=1.2V}
N 106230 -400 106230 -330 {lab=Vss}
N 106040 -330 106230 -330 {lab=Vss}
N 105810 -820 105860 -820 {lab=#net495}
N 105810 -820 105810 -460 {lab=#net495}
N 105810 -400 105810 -360 {lab=1.2V}
N 105810 -360 106320 -360 {lab=1.2V}
N 106560 -820 106600 -820 {lab=#net496}
N 106600 -820 106600 -460 {lab=#net496}
N 106690 -820 106730 -820 {lab=#net497}
N 106690 -820 106690 -460 {lab=#net497}
N 106690 -400 106690 -360 {lab=1.2V}
N 106320 -360 106690 -360 {lab=1.2V}
N 106600 -400 106600 -330 {lab=Vss}
N 106230 -330 106600 -330 {lab=Vss}
N 107190 -960 107190 -850 {lab=Gdrive}
N 107280 -960 107360 -960 {lab=Gdrive}
N 107360 -960 107360 -850 {lab=Gdrive}
N 107190 -790 107190 -700 {lab=Gate[71]}
N 107280 -700 107360 -700 {lab=Gate[71]}
N 107360 -790 107360 -700 {lab=Gate[71]}
N 107500 -790 107500 -650 {lab=Gate[71]}
N 107390 -650 107500 -650 {lab=Gate[71]}
N 107280 -700 107280 -650 {lab=Gate[71]}
N 107190 -700 107280 -700 {lab=Gate[71]}
N 107390 -650 107390 -570 {lab=Gate[71]}
N 107280 -650 107390 -650 {lab=Gate[71]}
N 107440 -820 107460 -820 {lab=ctrl_n[71]}
N 107690 -960 107690 -850 {lab=Ssense}
N 107780 -960 107860 -960 {lab=Ssense}
N 107860 -960 107860 -850 {lab=Ssense}
N 107690 -790 107690 -700 {lab=Source[71]}
N 107780 -700 107860 -700 {lab=Source[71]}
N 107860 -790 107860 -700 {lab=Source[71]}
N 107780 -700 107780 -650 {lab=Source[71]}
N 107690 -700 107780 -700 {lab=Source[71]}
N 108060 -960 108060 -850 {lab=Sforce}
N 108150 -960 108230 -960 {lab=Sforce}
N 108230 -960 108230 -850 {lab=Sforce}
N 108060 -790 108060 -700 {lab=Source[71]}
N 108150 -700 108230 -700 {lab=Source[71]}
N 108230 -790 108230 -700 {lab=Source[71]}
N 108150 -700 108150 -650 {lab=Source[71]}
N 108060 -700 108150 -700 {lab=Source[71]}
N 107960 -650 108150 -650 {lab=Source[71]}
N 108150 -1140 109650 -1140 {lab=Sforce}
N 108150 -1140 108150 -960 {lab=Sforce}
N 108060 -960 108150 -960 {lab=Sforce}
N 107780 -1170 109280 -1170 {lab=Ssense}
N 107780 -1170 107780 -960 {lab=Ssense}
N 107690 -960 107780 -960 {lab=Ssense}
N 107280 -1200 108780 -1200 {lab=Gdrive}
N 107280 -1200 107280 -960 {lab=Gdrive}
N 107190 -960 107280 -960 {lab=Gdrive}
N 107500 -1230 109000 -1230 {lab=Vcl}
N 107500 -1230 107500 -850 {lab=Vcl}
N 107740 -1380 107740 -1350 {lab=ctrl_p[71]}
N 107610 -1350 107740 -1350 {lab=ctrl_p[71]}
N 107110 -1350 107110 -820 {lab=ctrl_p[71]}
N 107110 -820 107150 -820 {lab=ctrl_p[71]}
N 107610 -820 107650 -820 {lab=ctrl_p[71]}
N 107610 -1350 107610 -820 {lab=ctrl_p[71]}
N 107110 -1350 107610 -1350 {lab=ctrl_p[71]}
N 107440 -1320 107440 -820 {lab=ctrl_n[71]}
N 107400 -820 107440 -820 {lab=ctrl_n[71]}
N 107440 -1320 107790 -1320 {lab=ctrl_n[71]}
N 107790 -1380 107790 -1320 {lab=ctrl_n[71]}
N 107900 -820 107940 -820 {lab=ctrl_n[71]}
N 107980 -820 108020 -820 {lab=ctrl_p[71]}
N 107940 -1320 108300 -1320 {lab=ctrl_n[71]}
N 107940 -1320 107940 -820 {lab=ctrl_n[71]}
N 107790 -1320 107940 -1320 {lab=ctrl_n[71]}
N 107740 -1350 107980 -1350 {lab=ctrl_p[71]}
N 107980 -1350 107980 -820 {lab=ctrl_p[71]}
N 108300 -1320 108300 -820 {lab=ctrl_n[71]}
N 108270 -820 108300 -820 {lab=ctrl_n[71]}
N 107960 -650 107960 -580 {lab=Source[71]}
N 107780 -650 107960 -650 {lab=Source[71]}
N 107190 -820 107230 -820 {lab=#net498}
N 107230 -820 107230 -460 {lab=#net498}
N 107500 -820 107540 -820 {lab=#net499}
N 107540 -820 107540 -460 {lab=#net499}
N 107230 -400 107230 -330 {lab=Vss}
N 108100 -330 108400 -330 {lab=Vss}
N 108400 -1080 108400 -330 {lab=Vss}
N 108400 -1080 109900 -1080 {lab=Vss}
N 108370 -1110 109870 -1110 {lab=1.2V}
N 108370 -1110 108370 -360 {lab=1.2V}
N 107540 -400 107540 -330 {lab=Vss}
N 107230 -330 107540 -330 {lab=Vss}
N 108190 -360 108370 -360 {lab=1.2V}
N 107820 -820 107860 -820 {lab=#net500}
N 107820 -820 107820 -460 {lab=#net500}
N 107690 -820 107730 -820 {lab=#net501}
N 107730 -820 107730 -460 {lab=#net501}
N 107820 -400 107820 -360 {lab=1.2V}
N 107730 -400 107730 -330 {lab=Vss}
N 107540 -330 107730 -330 {lab=Vss}
N 107310 -820 107360 -820 {lab=#net502}
N 107310 -820 107310 -460 {lab=#net502}
N 107310 -400 107310 -360 {lab=1.2V}
N 107310 -360 107820 -360 {lab=1.2V}
N 108060 -820 108100 -820 {lab=#net503}
N 108100 -820 108100 -460 {lab=#net503}
N 108190 -820 108230 -820 {lab=#net504}
N 108190 -820 108190 -460 {lab=#net504}
N 108190 -400 108190 -360 {lab=1.2V}
N 107820 -360 108190 -360 {lab=1.2V}
N 108100 -400 108100 -330 {lab=Vss}
N 107730 -330 108100 -330 {lab=Vss}
N 108690 -960 108690 -850 {lab=Gdrive}
N 108780 -960 108860 -960 {lab=Gdrive}
N 108860 -960 108860 -850 {lab=Gdrive}
N 108690 -790 108690 -700 {lab=Gate[72]}
N 108780 -700 108860 -700 {lab=Gate[72]}
N 108860 -790 108860 -700 {lab=Gate[72]}
N 109000 -790 109000 -650 {lab=Gate[72]}
N 108890 -650 109000 -650 {lab=Gate[72]}
N 108780 -700 108780 -650 {lab=Gate[72]}
N 108690 -700 108780 -700 {lab=Gate[72]}
N 108890 -650 108890 -570 {lab=Gate[72]}
N 108780 -650 108890 -650 {lab=Gate[72]}
N 108940 -820 108960 -820 {lab=ctrl_n[72]}
N 109190 -960 109190 -850 {lab=Ssense}
N 109280 -960 109360 -960 {lab=Ssense}
N 109360 -960 109360 -850 {lab=Ssense}
N 109190 -790 109190 -700 {lab=Source[72]}
N 109280 -700 109360 -700 {lab=Source[72]}
N 109360 -790 109360 -700 {lab=Source[72]}
N 109280 -700 109280 -650 {lab=Source[72]}
N 109190 -700 109280 -700 {lab=Source[72]}
N 109560 -960 109560 -850 {lab=Sforce}
N 109650 -960 109730 -960 {lab=Sforce}
N 109730 -960 109730 -850 {lab=Sforce}
N 109560 -790 109560 -700 {lab=Source[72]}
N 109650 -700 109730 -700 {lab=Source[72]}
N 109730 -790 109730 -700 {lab=Source[72]}
N 109650 -700 109650 -650 {lab=Source[72]}
N 109560 -700 109650 -700 {lab=Source[72]}
N 109460 -650 109650 -650 {lab=Source[72]}
N 109650 -1140 111150 -1140 {lab=Sforce}
N 109650 -1140 109650 -960 {lab=Sforce}
N 109560 -960 109650 -960 {lab=Sforce}
N 109280 -1170 110780 -1170 {lab=Ssense}
N 109280 -1170 109280 -960 {lab=Ssense}
N 109190 -960 109280 -960 {lab=Ssense}
N 108780 -1200 110280 -1200 {lab=Gdrive}
N 108780 -1200 108780 -960 {lab=Gdrive}
N 108690 -960 108780 -960 {lab=Gdrive}
N 109000 -1230 110500 -1230 {lab=Vcl}
N 109000 -1230 109000 -850 {lab=Vcl}
N 109240 -1380 109240 -1350 {lab=ctrl_p[72]}
N 109110 -1350 109240 -1350 {lab=ctrl_p[72]}
N 108610 -1350 108610 -820 {lab=ctrl_p[72]}
N 108610 -820 108650 -820 {lab=ctrl_p[72]}
N 109110 -820 109150 -820 {lab=ctrl_p[72]}
N 109110 -1350 109110 -820 {lab=ctrl_p[72]}
N 108610 -1350 109110 -1350 {lab=ctrl_p[72]}
N 108940 -1320 108940 -820 {lab=ctrl_n[72]}
N 108900 -820 108940 -820 {lab=ctrl_n[72]}
N 108940 -1320 109290 -1320 {lab=ctrl_n[72]}
N 109290 -1380 109290 -1320 {lab=ctrl_n[72]}
N 109400 -820 109440 -820 {lab=ctrl_n[72]}
N 109480 -820 109520 -820 {lab=ctrl_p[72]}
N 109440 -1320 109800 -1320 {lab=ctrl_n[72]}
N 109440 -1320 109440 -820 {lab=ctrl_n[72]}
N 109290 -1320 109440 -1320 {lab=ctrl_n[72]}
N 109240 -1350 109480 -1350 {lab=ctrl_p[72]}
N 109480 -1350 109480 -820 {lab=ctrl_p[72]}
N 109800 -1320 109800 -820 {lab=ctrl_n[72]}
N 109770 -820 109800 -820 {lab=ctrl_n[72]}
N 109460 -650 109460 -580 {lab=Source[72]}
N 109280 -650 109460 -650 {lab=Source[72]}
N 108690 -820 108730 -820 {lab=#net505}
N 108730 -820 108730 -460 {lab=#net505}
N 109000 -820 109040 -820 {lab=#net506}
N 109040 -820 109040 -460 {lab=#net506}
N 108730 -400 108730 -330 {lab=Vss}
N 109600 -330 109900 -330 {lab=Vss}
N 109900 -1080 109900 -330 {lab=Vss}
N 109900 -1080 111400 -1080 {lab=Vss}
N 109870 -1110 111370 -1110 {lab=1.2V}
N 109870 -1110 109870 -360 {lab=1.2V}
N 109040 -400 109040 -330 {lab=Vss}
N 108730 -330 109040 -330 {lab=Vss}
N 109690 -360 109870 -360 {lab=1.2V}
N 109320 -820 109360 -820 {lab=#net507}
N 109320 -820 109320 -460 {lab=#net507}
N 109190 -820 109230 -820 {lab=#net508}
N 109230 -820 109230 -460 {lab=#net508}
N 109320 -400 109320 -360 {lab=1.2V}
N 109230 -400 109230 -330 {lab=Vss}
N 109040 -330 109230 -330 {lab=Vss}
N 108810 -820 108860 -820 {lab=#net509}
N 108810 -820 108810 -460 {lab=#net509}
N 108810 -400 108810 -360 {lab=1.2V}
N 108810 -360 109320 -360 {lab=1.2V}
N 109560 -820 109600 -820 {lab=#net510}
N 109600 -820 109600 -460 {lab=#net510}
N 109690 -820 109730 -820 {lab=#net511}
N 109690 -820 109690 -460 {lab=#net511}
N 109690 -400 109690 -360 {lab=1.2V}
N 109320 -360 109690 -360 {lab=1.2V}
N 109600 -400 109600 -330 {lab=Vss}
N 109230 -330 109600 -330 {lab=Vss}
N 110190 -960 110190 -850 {lab=Gdrive}
N 110280 -960 110360 -960 {lab=Gdrive}
N 110360 -960 110360 -850 {lab=Gdrive}
N 110190 -790 110190 -700 {lab=Gate[73]}
N 110280 -700 110360 -700 {lab=Gate[73]}
N 110360 -790 110360 -700 {lab=Gate[73]}
N 110500 -790 110500 -650 {lab=Gate[73]}
N 110390 -650 110500 -650 {lab=Gate[73]}
N 110280 -700 110280 -650 {lab=Gate[73]}
N 110190 -700 110280 -700 {lab=Gate[73]}
N 110390 -650 110390 -570 {lab=Gate[73]}
N 110280 -650 110390 -650 {lab=Gate[73]}
N 110440 -820 110460 -820 {lab=ctrl_n[73]}
N 110690 -960 110690 -850 {lab=Ssense}
N 110780 -960 110860 -960 {lab=Ssense}
N 110860 -960 110860 -850 {lab=Ssense}
N 110690 -790 110690 -700 {lab=Source[73]}
N 110780 -700 110860 -700 {lab=Source[73]}
N 110860 -790 110860 -700 {lab=Source[73]}
N 110780 -700 110780 -650 {lab=Source[73]}
N 110690 -700 110780 -700 {lab=Source[73]}
N 111060 -960 111060 -850 {lab=Sforce}
N 111150 -960 111230 -960 {lab=Sforce}
N 111230 -960 111230 -850 {lab=Sforce}
N 111060 -790 111060 -700 {lab=Source[73]}
N 111150 -700 111230 -700 {lab=Source[73]}
N 111230 -790 111230 -700 {lab=Source[73]}
N 111150 -700 111150 -650 {lab=Source[73]}
N 111060 -700 111150 -700 {lab=Source[73]}
N 110960 -650 111150 -650 {lab=Source[73]}
N 111150 -1140 112650 -1140 {lab=Sforce}
N 111150 -1140 111150 -960 {lab=Sforce}
N 111060 -960 111150 -960 {lab=Sforce}
N 110780 -1170 112280 -1170 {lab=Ssense}
N 110780 -1170 110780 -960 {lab=Ssense}
N 110690 -960 110780 -960 {lab=Ssense}
N 110280 -1200 111780 -1200 {lab=Gdrive}
N 110280 -1200 110280 -960 {lab=Gdrive}
N 110190 -960 110280 -960 {lab=Gdrive}
N 110500 -1230 112000 -1230 {lab=Vcl}
N 110500 -1230 110500 -850 {lab=Vcl}
N 110740 -1380 110740 -1350 {lab=ctrl_p[73]}
N 110610 -1350 110740 -1350 {lab=ctrl_p[73]}
N 110110 -1350 110110 -820 {lab=ctrl_p[73]}
N 110110 -820 110150 -820 {lab=ctrl_p[73]}
N 110610 -820 110650 -820 {lab=ctrl_p[73]}
N 110610 -1350 110610 -820 {lab=ctrl_p[73]}
N 110110 -1350 110610 -1350 {lab=ctrl_p[73]}
N 110440 -1320 110440 -820 {lab=ctrl_n[73]}
N 110400 -820 110440 -820 {lab=ctrl_n[73]}
N 110440 -1320 110790 -1320 {lab=ctrl_n[73]}
N 110790 -1380 110790 -1320 {lab=ctrl_n[73]}
N 110900 -820 110940 -820 {lab=ctrl_n[73]}
N 110980 -820 111020 -820 {lab=ctrl_p[73]}
N 110940 -1320 111300 -1320 {lab=ctrl_n[73]}
N 110940 -1320 110940 -820 {lab=ctrl_n[73]}
N 110790 -1320 110940 -1320 {lab=ctrl_n[73]}
N 110740 -1350 110980 -1350 {lab=ctrl_p[73]}
N 110980 -1350 110980 -820 {lab=ctrl_p[73]}
N 111300 -1320 111300 -820 {lab=ctrl_n[73]}
N 111270 -820 111300 -820 {lab=ctrl_n[73]}
N 110960 -650 110960 -580 {lab=Source[73]}
N 110780 -650 110960 -650 {lab=Source[73]}
N 110190 -820 110230 -820 {lab=#net512}
N 110230 -820 110230 -460 {lab=#net512}
N 110500 -820 110540 -820 {lab=#net513}
N 110540 -820 110540 -460 {lab=#net513}
N 110230 -400 110230 -330 {lab=Vss}
N 111100 -330 111400 -330 {lab=Vss}
N 111400 -1080 111400 -330 {lab=Vss}
N 111400 -1080 112900 -1080 {lab=Vss}
N 111370 -1110 112870 -1110 {lab=1.2V}
N 111370 -1110 111370 -360 {lab=1.2V}
N 110540 -400 110540 -330 {lab=Vss}
N 110230 -330 110540 -330 {lab=Vss}
N 111190 -360 111370 -360 {lab=1.2V}
N 110820 -820 110860 -820 {lab=#net514}
N 110820 -820 110820 -460 {lab=#net514}
N 110690 -820 110730 -820 {lab=#net515}
N 110730 -820 110730 -460 {lab=#net515}
N 110820 -400 110820 -360 {lab=1.2V}
N 110730 -400 110730 -330 {lab=Vss}
N 110540 -330 110730 -330 {lab=Vss}
N 110310 -820 110360 -820 {lab=#net516}
N 110310 -820 110310 -460 {lab=#net516}
N 110310 -400 110310 -360 {lab=1.2V}
N 110310 -360 110820 -360 {lab=1.2V}
N 111060 -820 111100 -820 {lab=#net517}
N 111100 -820 111100 -460 {lab=#net517}
N 111190 -820 111230 -820 {lab=#net518}
N 111190 -820 111190 -460 {lab=#net518}
N 111190 -400 111190 -360 {lab=1.2V}
N 110820 -360 111190 -360 {lab=1.2V}
N 111100 -400 111100 -330 {lab=Vss}
N 110730 -330 111100 -330 {lab=Vss}
N 111690 -960 111690 -850 {lab=Gdrive}
N 111780 -960 111860 -960 {lab=Gdrive}
N 111860 -960 111860 -850 {lab=Gdrive}
N 111690 -790 111690 -700 {lab=Gate[74]}
N 111780 -700 111860 -700 {lab=Gate[74]}
N 111860 -790 111860 -700 {lab=Gate[74]}
N 112000 -790 112000 -650 {lab=Gate[74]}
N 111890 -650 112000 -650 {lab=Gate[74]}
N 111780 -700 111780 -650 {lab=Gate[74]}
N 111690 -700 111780 -700 {lab=Gate[74]}
N 111890 -650 111890 -570 {lab=Gate[74]}
N 111780 -650 111890 -650 {lab=Gate[74]}
N 111940 -820 111960 -820 {lab=ctrl_n[74]}
N 112190 -960 112190 -850 {lab=Ssense}
N 112280 -960 112360 -960 {lab=Ssense}
N 112360 -960 112360 -850 {lab=Ssense}
N 112190 -790 112190 -700 {lab=Source[74]}
N 112280 -700 112360 -700 {lab=Source[74]}
N 112360 -790 112360 -700 {lab=Source[74]}
N 112280 -700 112280 -650 {lab=Source[74]}
N 112190 -700 112280 -700 {lab=Source[74]}
N 112560 -960 112560 -850 {lab=Sforce}
N 112650 -960 112730 -960 {lab=Sforce}
N 112730 -960 112730 -850 {lab=Sforce}
N 112560 -790 112560 -700 {lab=Source[74]}
N 112650 -700 112730 -700 {lab=Source[74]}
N 112730 -790 112730 -700 {lab=Source[74]}
N 112650 -700 112650 -650 {lab=Source[74]}
N 112560 -700 112650 -700 {lab=Source[74]}
N 112460 -650 112650 -650 {lab=Source[74]}
N 112650 -1140 114150 -1140 {lab=Sforce}
N 112650 -1140 112650 -960 {lab=Sforce}
N 112560 -960 112650 -960 {lab=Sforce}
N 112280 -1170 113780 -1170 {lab=Ssense}
N 112280 -1170 112280 -960 {lab=Ssense}
N 112190 -960 112280 -960 {lab=Ssense}
N 111780 -1200 113280 -1200 {lab=Gdrive}
N 111780 -1200 111780 -960 {lab=Gdrive}
N 111690 -960 111780 -960 {lab=Gdrive}
N 112000 -1230 113500 -1230 {lab=Vcl}
N 112000 -1230 112000 -850 {lab=Vcl}
N 112240 -1380 112240 -1350 {lab=ctrl_p[74]}
N 112110 -1350 112240 -1350 {lab=ctrl_p[74]}
N 111610 -1350 111610 -820 {lab=ctrl_p[74]}
N 111610 -820 111650 -820 {lab=ctrl_p[74]}
N 112110 -820 112150 -820 {lab=ctrl_p[74]}
N 112110 -1350 112110 -820 {lab=ctrl_p[74]}
N 111610 -1350 112110 -1350 {lab=ctrl_p[74]}
N 111940 -1320 111940 -820 {lab=ctrl_n[74]}
N 111900 -820 111940 -820 {lab=ctrl_n[74]}
N 111940 -1320 112290 -1320 {lab=ctrl_n[74]}
N 112290 -1380 112290 -1320 {lab=ctrl_n[74]}
N 112400 -820 112440 -820 {lab=ctrl_n[74]}
N 112480 -820 112520 -820 {lab=ctrl_p[74]}
N 112440 -1320 112800 -1320 {lab=ctrl_n[74]}
N 112440 -1320 112440 -820 {lab=ctrl_n[74]}
N 112290 -1320 112440 -1320 {lab=ctrl_n[74]}
N 112240 -1350 112480 -1350 {lab=ctrl_p[74]}
N 112480 -1350 112480 -820 {lab=ctrl_p[74]}
N 112800 -1320 112800 -820 {lab=ctrl_n[74]}
N 112770 -820 112800 -820 {lab=ctrl_n[74]}
N 112460 -650 112460 -580 {lab=Source[74]}
N 112280 -650 112460 -650 {lab=Source[74]}
N 111690 -820 111730 -820 {lab=#net519}
N 111730 -820 111730 -460 {lab=#net519}
N 112000 -820 112040 -820 {lab=#net520}
N 112040 -820 112040 -460 {lab=#net520}
N 111730 -400 111730 -330 {lab=Vss}
N 112600 -330 112900 -330 {lab=Vss}
N 112900 -1080 112900 -330 {lab=Vss}
N 112900 -1080 114400 -1080 {lab=Vss}
N 112870 -1110 114370 -1110 {lab=1.2V}
N 112870 -1110 112870 -360 {lab=1.2V}
N 112040 -400 112040 -330 {lab=Vss}
N 111730 -330 112040 -330 {lab=Vss}
N 112690 -360 112870 -360 {lab=1.2V}
N 112320 -820 112360 -820 {lab=#net521}
N 112320 -820 112320 -460 {lab=#net521}
N 112190 -820 112230 -820 {lab=#net522}
N 112230 -820 112230 -460 {lab=#net522}
N 112320 -400 112320 -360 {lab=1.2V}
N 112230 -400 112230 -330 {lab=Vss}
N 112040 -330 112230 -330 {lab=Vss}
N 111810 -820 111860 -820 {lab=#net523}
N 111810 -820 111810 -460 {lab=#net523}
N 111810 -400 111810 -360 {lab=1.2V}
N 111810 -360 112320 -360 {lab=1.2V}
N 112560 -820 112600 -820 {lab=#net524}
N 112600 -820 112600 -460 {lab=#net524}
N 112690 -820 112730 -820 {lab=#net525}
N 112690 -820 112690 -460 {lab=#net525}
N 112690 -400 112690 -360 {lab=1.2V}
N 112320 -360 112690 -360 {lab=1.2V}
N 112600 -400 112600 -330 {lab=Vss}
N 112230 -330 112600 -330 {lab=Vss}
N 113190 -960 113190 -850 {lab=Gdrive}
N 113280 -960 113360 -960 {lab=Gdrive}
N 113360 -960 113360 -850 {lab=Gdrive}
N 113190 -790 113190 -700 {lab=Gate[75]}
N 113280 -700 113360 -700 {lab=Gate[75]}
N 113360 -790 113360 -700 {lab=Gate[75]}
N 113500 -790 113500 -650 {lab=Gate[75]}
N 113390 -650 113500 -650 {lab=Gate[75]}
N 113280 -700 113280 -650 {lab=Gate[75]}
N 113190 -700 113280 -700 {lab=Gate[75]}
N 113390 -650 113390 -570 {lab=Gate[75]}
N 113280 -650 113390 -650 {lab=Gate[75]}
N 113440 -820 113460 -820 {lab=ctrl_n[75]}
N 113690 -960 113690 -850 {lab=Ssense}
N 113780 -960 113860 -960 {lab=Ssense}
N 113860 -960 113860 -850 {lab=Ssense}
N 113690 -790 113690 -700 {lab=Source[75]}
N 113780 -700 113860 -700 {lab=Source[75]}
N 113860 -790 113860 -700 {lab=Source[75]}
N 113780 -700 113780 -650 {lab=Source[75]}
N 113690 -700 113780 -700 {lab=Source[75]}
N 114060 -960 114060 -850 {lab=Sforce}
N 114150 -960 114230 -960 {lab=Sforce}
N 114230 -960 114230 -850 {lab=Sforce}
N 114060 -790 114060 -700 {lab=Source[75]}
N 114150 -700 114230 -700 {lab=Source[75]}
N 114230 -790 114230 -700 {lab=Source[75]}
N 114150 -700 114150 -650 {lab=Source[75]}
N 114060 -700 114150 -700 {lab=Source[75]}
N 113960 -650 114150 -650 {lab=Source[75]}
N 114150 -1140 115650 -1140 {lab=Sforce}
N 114150 -1140 114150 -960 {lab=Sforce}
N 114060 -960 114150 -960 {lab=Sforce}
N 113780 -1170 115280 -1170 {lab=Ssense}
N 113780 -1170 113780 -960 {lab=Ssense}
N 113690 -960 113780 -960 {lab=Ssense}
N 113280 -1200 114780 -1200 {lab=Gdrive}
N 113280 -1200 113280 -960 {lab=Gdrive}
N 113190 -960 113280 -960 {lab=Gdrive}
N 113500 -1230 115000 -1230 {lab=Vcl}
N 113500 -1230 113500 -850 {lab=Vcl}
N 113740 -1380 113740 -1350 {lab=ctrl_p[75]}
N 113610 -1350 113740 -1350 {lab=ctrl_p[75]}
N 113110 -1350 113110 -820 {lab=ctrl_p[75]}
N 113110 -820 113150 -820 {lab=ctrl_p[75]}
N 113610 -820 113650 -820 {lab=ctrl_p[75]}
N 113610 -1350 113610 -820 {lab=ctrl_p[75]}
N 113110 -1350 113610 -1350 {lab=ctrl_p[75]}
N 113440 -1320 113440 -820 {lab=ctrl_n[75]}
N 113400 -820 113440 -820 {lab=ctrl_n[75]}
N 113440 -1320 113790 -1320 {lab=ctrl_n[75]}
N 113790 -1380 113790 -1320 {lab=ctrl_n[75]}
N 113900 -820 113940 -820 {lab=ctrl_n[75]}
N 113980 -820 114020 -820 {lab=ctrl_p[75]}
N 113940 -1320 114300 -1320 {lab=ctrl_n[75]}
N 113940 -1320 113940 -820 {lab=ctrl_n[75]}
N 113790 -1320 113940 -1320 {lab=ctrl_n[75]}
N 113740 -1350 113980 -1350 {lab=ctrl_p[75]}
N 113980 -1350 113980 -820 {lab=ctrl_p[75]}
N 114300 -1320 114300 -820 {lab=ctrl_n[75]}
N 114270 -820 114300 -820 {lab=ctrl_n[75]}
N 113960 -650 113960 -580 {lab=Source[75]}
N 113780 -650 113960 -650 {lab=Source[75]}
N 113190 -820 113230 -820 {lab=#net526}
N 113230 -820 113230 -460 {lab=#net526}
N 113500 -820 113540 -820 {lab=#net527}
N 113540 -820 113540 -460 {lab=#net527}
N 113230 -400 113230 -330 {lab=Vss}
N 114100 -330 114400 -330 {lab=Vss}
N 114400 -1080 114400 -330 {lab=Vss}
N 114400 -1080 115900 -1080 {lab=Vss}
N 114370 -1110 115870 -1110 {lab=1.2V}
N 114370 -1110 114370 -360 {lab=1.2V}
N 113540 -400 113540 -330 {lab=Vss}
N 113230 -330 113540 -330 {lab=Vss}
N 114190 -360 114370 -360 {lab=1.2V}
N 113820 -820 113860 -820 {lab=#net528}
N 113820 -820 113820 -460 {lab=#net528}
N 113690 -820 113730 -820 {lab=#net529}
N 113730 -820 113730 -460 {lab=#net529}
N 113820 -400 113820 -360 {lab=1.2V}
N 113730 -400 113730 -330 {lab=Vss}
N 113540 -330 113730 -330 {lab=Vss}
N 113310 -820 113360 -820 {lab=#net530}
N 113310 -820 113310 -460 {lab=#net530}
N 113310 -400 113310 -360 {lab=1.2V}
N 113310 -360 113820 -360 {lab=1.2V}
N 114060 -820 114100 -820 {lab=#net531}
N 114100 -820 114100 -460 {lab=#net531}
N 114190 -820 114230 -820 {lab=#net532}
N 114190 -820 114190 -460 {lab=#net532}
N 114190 -400 114190 -360 {lab=1.2V}
N 113820 -360 114190 -360 {lab=1.2V}
N 114100 -400 114100 -330 {lab=Vss}
N 113730 -330 114100 -330 {lab=Vss}
N 114690 -960 114690 -850 {lab=Gdrive}
N 114780 -960 114860 -960 {lab=Gdrive}
N 114860 -960 114860 -850 {lab=Gdrive}
N 114690 -790 114690 -700 {lab=Gate[76]}
N 114780 -700 114860 -700 {lab=Gate[76]}
N 114860 -790 114860 -700 {lab=Gate[76]}
N 115000 -790 115000 -650 {lab=Gate[76]}
N 114890 -650 115000 -650 {lab=Gate[76]}
N 114780 -700 114780 -650 {lab=Gate[76]}
N 114690 -700 114780 -700 {lab=Gate[76]}
N 114890 -650 114890 -570 {lab=Gate[76]}
N 114780 -650 114890 -650 {lab=Gate[76]}
N 114940 -820 114960 -820 {lab=ctrl_n[76]}
N 115190 -960 115190 -850 {lab=Ssense}
N 115280 -960 115360 -960 {lab=Ssense}
N 115360 -960 115360 -850 {lab=Ssense}
N 115190 -790 115190 -700 {lab=Source[76]}
N 115280 -700 115360 -700 {lab=Source[76]}
N 115360 -790 115360 -700 {lab=Source[76]}
N 115280 -700 115280 -650 {lab=Source[76]}
N 115190 -700 115280 -700 {lab=Source[76]}
N 115560 -960 115560 -850 {lab=Sforce}
N 115650 -960 115730 -960 {lab=Sforce}
N 115730 -960 115730 -850 {lab=Sforce}
N 115560 -790 115560 -700 {lab=Source[76]}
N 115650 -700 115730 -700 {lab=Source[76]}
N 115730 -790 115730 -700 {lab=Source[76]}
N 115650 -700 115650 -650 {lab=Source[76]}
N 115560 -700 115650 -700 {lab=Source[76]}
N 115460 -650 115650 -650 {lab=Source[76]}
N 115650 -1140 117150 -1140 {lab=Sforce}
N 115650 -1140 115650 -960 {lab=Sforce}
N 115560 -960 115650 -960 {lab=Sforce}
N 115280 -1170 116780 -1170 {lab=Ssense}
N 115280 -1170 115280 -960 {lab=Ssense}
N 115190 -960 115280 -960 {lab=Ssense}
N 114780 -1200 116280 -1200 {lab=Gdrive}
N 114780 -1200 114780 -960 {lab=Gdrive}
N 114690 -960 114780 -960 {lab=Gdrive}
N 115000 -1230 116500 -1230 {lab=Vcl}
N 115000 -1230 115000 -850 {lab=Vcl}
N 115240 -1380 115240 -1350 {lab=ctrl_p[76]}
N 115110 -1350 115240 -1350 {lab=ctrl_p[76]}
N 114610 -1350 114610 -820 {lab=ctrl_p[76]}
N 114610 -820 114650 -820 {lab=ctrl_p[76]}
N 115110 -820 115150 -820 {lab=ctrl_p[76]}
N 115110 -1350 115110 -820 {lab=ctrl_p[76]}
N 114610 -1350 115110 -1350 {lab=ctrl_p[76]}
N 114940 -1320 114940 -820 {lab=ctrl_n[76]}
N 114900 -820 114940 -820 {lab=ctrl_n[76]}
N 114940 -1320 115290 -1320 {lab=ctrl_n[76]}
N 115290 -1380 115290 -1320 {lab=ctrl_n[76]}
N 115400 -820 115440 -820 {lab=ctrl_n[76]}
N 115480 -820 115520 -820 {lab=ctrl_p[76]}
N 115440 -1320 115800 -1320 {lab=ctrl_n[76]}
N 115440 -1320 115440 -820 {lab=ctrl_n[76]}
N 115290 -1320 115440 -1320 {lab=ctrl_n[76]}
N 115240 -1350 115480 -1350 {lab=ctrl_p[76]}
N 115480 -1350 115480 -820 {lab=ctrl_p[76]}
N 115800 -1320 115800 -820 {lab=ctrl_n[76]}
N 115770 -820 115800 -820 {lab=ctrl_n[76]}
N 115460 -650 115460 -580 {lab=Source[76]}
N 115280 -650 115460 -650 {lab=Source[76]}
N 114690 -820 114730 -820 {lab=#net533}
N 114730 -820 114730 -460 {lab=#net533}
N 115000 -820 115040 -820 {lab=#net534}
N 115040 -820 115040 -460 {lab=#net534}
N 114730 -400 114730 -330 {lab=Vss}
N 115600 -330 115900 -330 {lab=Vss}
N 115900 -1080 115900 -330 {lab=Vss}
N 115900 -1080 117400 -1080 {lab=Vss}
N 115870 -1110 117370 -1110 {lab=1.2V}
N 115870 -1110 115870 -360 {lab=1.2V}
N 115040 -400 115040 -330 {lab=Vss}
N 114730 -330 115040 -330 {lab=Vss}
N 115690 -360 115870 -360 {lab=1.2V}
N 115320 -820 115360 -820 {lab=#net535}
N 115320 -820 115320 -460 {lab=#net535}
N 115190 -820 115230 -820 {lab=#net536}
N 115230 -820 115230 -460 {lab=#net536}
N 115320 -400 115320 -360 {lab=1.2V}
N 115230 -400 115230 -330 {lab=Vss}
N 115040 -330 115230 -330 {lab=Vss}
N 114810 -820 114860 -820 {lab=#net537}
N 114810 -820 114810 -460 {lab=#net537}
N 114810 -400 114810 -360 {lab=1.2V}
N 114810 -360 115320 -360 {lab=1.2V}
N 115560 -820 115600 -820 {lab=#net538}
N 115600 -820 115600 -460 {lab=#net538}
N 115690 -820 115730 -820 {lab=#net539}
N 115690 -820 115690 -460 {lab=#net539}
N 115690 -400 115690 -360 {lab=1.2V}
N 115320 -360 115690 -360 {lab=1.2V}
N 115600 -400 115600 -330 {lab=Vss}
N 115230 -330 115600 -330 {lab=Vss}
N 116190 -960 116190 -850 {lab=Gdrive}
N 116280 -960 116360 -960 {lab=Gdrive}
N 116360 -960 116360 -850 {lab=Gdrive}
N 116190 -790 116190 -700 {lab=Gate[77]}
N 116280 -700 116360 -700 {lab=Gate[77]}
N 116360 -790 116360 -700 {lab=Gate[77]}
N 116500 -790 116500 -650 {lab=Gate[77]}
N 116390 -650 116500 -650 {lab=Gate[77]}
N 116280 -700 116280 -650 {lab=Gate[77]}
N 116190 -700 116280 -700 {lab=Gate[77]}
N 116390 -650 116390 -570 {lab=Gate[77]}
N 116280 -650 116390 -650 {lab=Gate[77]}
N 116440 -820 116460 -820 {lab=ctrl_n[77]}
N 116690 -960 116690 -850 {lab=Ssense}
N 116780 -960 116860 -960 {lab=Ssense}
N 116860 -960 116860 -850 {lab=Ssense}
N 116690 -790 116690 -700 {lab=Source[77]}
N 116780 -700 116860 -700 {lab=Source[77]}
N 116860 -790 116860 -700 {lab=Source[77]}
N 116780 -700 116780 -650 {lab=Source[77]}
N 116690 -700 116780 -700 {lab=Source[77]}
N 117060 -960 117060 -850 {lab=Sforce}
N 117150 -960 117230 -960 {lab=Sforce}
N 117230 -960 117230 -850 {lab=Sforce}
N 117060 -790 117060 -700 {lab=Source[77]}
N 117150 -700 117230 -700 {lab=Source[77]}
N 117230 -790 117230 -700 {lab=Source[77]}
N 117150 -700 117150 -650 {lab=Source[77]}
N 117060 -700 117150 -700 {lab=Source[77]}
N 116960 -650 117150 -650 {lab=Source[77]}
N 117150 -1140 118650 -1140 {lab=Sforce}
N 117150 -1140 117150 -960 {lab=Sforce}
N 117060 -960 117150 -960 {lab=Sforce}
N 116780 -1170 118280 -1170 {lab=Ssense}
N 116780 -1170 116780 -960 {lab=Ssense}
N 116690 -960 116780 -960 {lab=Ssense}
N 116280 -1200 117780 -1200 {lab=Gdrive}
N 116280 -1200 116280 -960 {lab=Gdrive}
N 116190 -960 116280 -960 {lab=Gdrive}
N 116500 -1230 118000 -1230 {lab=Vcl}
N 116500 -1230 116500 -850 {lab=Vcl}
N 116740 -1380 116740 -1350 {lab=ctrl_p[77]}
N 116610 -1350 116740 -1350 {lab=ctrl_p[77]}
N 116110 -1350 116110 -820 {lab=ctrl_p[77]}
N 116110 -820 116150 -820 {lab=ctrl_p[77]}
N 116610 -820 116650 -820 {lab=ctrl_p[77]}
N 116610 -1350 116610 -820 {lab=ctrl_p[77]}
N 116110 -1350 116610 -1350 {lab=ctrl_p[77]}
N 116440 -1320 116440 -820 {lab=ctrl_n[77]}
N 116400 -820 116440 -820 {lab=ctrl_n[77]}
N 116440 -1320 116790 -1320 {lab=ctrl_n[77]}
N 116790 -1380 116790 -1320 {lab=ctrl_n[77]}
N 116900 -820 116940 -820 {lab=ctrl_n[77]}
N 116980 -820 117020 -820 {lab=ctrl_p[77]}
N 116940 -1320 117300 -1320 {lab=ctrl_n[77]}
N 116940 -1320 116940 -820 {lab=ctrl_n[77]}
N 116790 -1320 116940 -1320 {lab=ctrl_n[77]}
N 116740 -1350 116980 -1350 {lab=ctrl_p[77]}
N 116980 -1350 116980 -820 {lab=ctrl_p[77]}
N 117300 -1320 117300 -820 {lab=ctrl_n[77]}
N 117270 -820 117300 -820 {lab=ctrl_n[77]}
N 116960 -650 116960 -580 {lab=Source[77]}
N 116780 -650 116960 -650 {lab=Source[77]}
N 116190 -820 116230 -820 {lab=#net540}
N 116230 -820 116230 -460 {lab=#net540}
N 116500 -820 116540 -820 {lab=#net541}
N 116540 -820 116540 -460 {lab=#net541}
N 116230 -400 116230 -330 {lab=Vss}
N 117100 -330 117400 -330 {lab=Vss}
N 117400 -1080 117400 -330 {lab=Vss}
N 117400 -1080 118900 -1080 {lab=Vss}
N 117370 -1110 118870 -1110 {lab=1.2V}
N 117370 -1110 117370 -360 {lab=1.2V}
N 116540 -400 116540 -330 {lab=Vss}
N 116230 -330 116540 -330 {lab=Vss}
N 117190 -360 117370 -360 {lab=1.2V}
N 116820 -820 116860 -820 {lab=#net542}
N 116820 -820 116820 -460 {lab=#net542}
N 116690 -820 116730 -820 {lab=#net543}
N 116730 -820 116730 -460 {lab=#net543}
N 116820 -400 116820 -360 {lab=1.2V}
N 116730 -400 116730 -330 {lab=Vss}
N 116540 -330 116730 -330 {lab=Vss}
N 116310 -820 116360 -820 {lab=#net544}
N 116310 -820 116310 -460 {lab=#net544}
N 116310 -400 116310 -360 {lab=1.2V}
N 116310 -360 116820 -360 {lab=1.2V}
N 117060 -820 117100 -820 {lab=#net545}
N 117100 -820 117100 -460 {lab=#net545}
N 117190 -820 117230 -820 {lab=#net546}
N 117190 -820 117190 -460 {lab=#net546}
N 117190 -400 117190 -360 {lab=1.2V}
N 116820 -360 117190 -360 {lab=1.2V}
N 117100 -400 117100 -330 {lab=Vss}
N 116730 -330 117100 -330 {lab=Vss}
N 117690 -960 117690 -850 {lab=Gdrive}
N 117780 -960 117860 -960 {lab=Gdrive}
N 117860 -960 117860 -850 {lab=Gdrive}
N 117690 -790 117690 -700 {lab=Gate[78]}
N 117780 -700 117860 -700 {lab=Gate[78]}
N 117860 -790 117860 -700 {lab=Gate[78]}
N 118000 -790 118000 -650 {lab=Gate[78]}
N 117890 -650 118000 -650 {lab=Gate[78]}
N 117780 -700 117780 -650 {lab=Gate[78]}
N 117690 -700 117780 -700 {lab=Gate[78]}
N 117890 -650 117890 -570 {lab=Gate[78]}
N 117780 -650 117890 -650 {lab=Gate[78]}
N 117940 -820 117960 -820 {lab=ctrl_n[78]}
N 118190 -960 118190 -850 {lab=Ssense}
N 118280 -960 118360 -960 {lab=Ssense}
N 118360 -960 118360 -850 {lab=Ssense}
N 118190 -790 118190 -700 {lab=Source[78]}
N 118280 -700 118360 -700 {lab=Source[78]}
N 118360 -790 118360 -700 {lab=Source[78]}
N 118280 -700 118280 -650 {lab=Source[78]}
N 118190 -700 118280 -700 {lab=Source[78]}
N 118560 -960 118560 -850 {lab=Sforce}
N 118650 -960 118730 -960 {lab=Sforce}
N 118730 -960 118730 -850 {lab=Sforce}
N 118560 -790 118560 -700 {lab=Source[78]}
N 118650 -700 118730 -700 {lab=Source[78]}
N 118730 -790 118730 -700 {lab=Source[78]}
N 118650 -700 118650 -650 {lab=Source[78]}
N 118560 -700 118650 -700 {lab=Source[78]}
N 118460 -650 118650 -650 {lab=Source[78]}
N 118650 -1140 120150 -1140 {lab=Sforce}
N 118650 -1140 118650 -960 {lab=Sforce}
N 118560 -960 118650 -960 {lab=Sforce}
N 118280 -1170 119780 -1170 {lab=Ssense}
N 118280 -1170 118280 -960 {lab=Ssense}
N 118190 -960 118280 -960 {lab=Ssense}
N 117780 -1200 119280 -1200 {lab=Gdrive}
N 117780 -1200 117780 -960 {lab=Gdrive}
N 117690 -960 117780 -960 {lab=Gdrive}
N 118000 -1230 119500 -1230 {lab=Vcl}
N 118000 -1230 118000 -850 {lab=Vcl}
N 118240 -1380 118240 -1350 {lab=ctrl_p[78]}
N 118110 -1350 118240 -1350 {lab=ctrl_p[78]}
N 117610 -1350 117610 -820 {lab=ctrl_p[78]}
N 117610 -820 117650 -820 {lab=ctrl_p[78]}
N 118110 -820 118150 -820 {lab=ctrl_p[78]}
N 118110 -1350 118110 -820 {lab=ctrl_p[78]}
N 117610 -1350 118110 -1350 {lab=ctrl_p[78]}
N 117940 -1320 117940 -820 {lab=ctrl_n[78]}
N 117900 -820 117940 -820 {lab=ctrl_n[78]}
N 117940 -1320 118290 -1320 {lab=ctrl_n[78]}
N 118290 -1380 118290 -1320 {lab=ctrl_n[78]}
N 118400 -820 118440 -820 {lab=ctrl_n[78]}
N 118480 -820 118520 -820 {lab=ctrl_p[78]}
N 118440 -1320 118800 -1320 {lab=ctrl_n[78]}
N 118440 -1320 118440 -820 {lab=ctrl_n[78]}
N 118290 -1320 118440 -1320 {lab=ctrl_n[78]}
N 118240 -1350 118480 -1350 {lab=ctrl_p[78]}
N 118480 -1350 118480 -820 {lab=ctrl_p[78]}
N 118800 -1320 118800 -820 {lab=ctrl_n[78]}
N 118770 -820 118800 -820 {lab=ctrl_n[78]}
N 118460 -650 118460 -580 {lab=Source[78]}
N 118280 -650 118460 -650 {lab=Source[78]}
N 117690 -820 117730 -820 {lab=#net547}
N 117730 -820 117730 -460 {lab=#net547}
N 118000 -820 118040 -820 {lab=#net548}
N 118040 -820 118040 -460 {lab=#net548}
N 117730 -400 117730 -330 {lab=Vss}
N 118600 -330 118900 -330 {lab=Vss}
N 118900 -1080 118900 -330 {lab=Vss}
N 118900 -1080 120400 -1080 {lab=Vss}
N 118870 -1110 120370 -1110 {lab=1.2V}
N 118870 -1110 118870 -360 {lab=1.2V}
N 118040 -400 118040 -330 {lab=Vss}
N 117730 -330 118040 -330 {lab=Vss}
N 118690 -360 118870 -360 {lab=1.2V}
N 118320 -820 118360 -820 {lab=#net549}
N 118320 -820 118320 -460 {lab=#net549}
N 118190 -820 118230 -820 {lab=#net550}
N 118230 -820 118230 -460 {lab=#net550}
N 118320 -400 118320 -360 {lab=1.2V}
N 118230 -400 118230 -330 {lab=Vss}
N 118040 -330 118230 -330 {lab=Vss}
N 117810 -820 117860 -820 {lab=#net551}
N 117810 -820 117810 -460 {lab=#net551}
N 117810 -400 117810 -360 {lab=1.2V}
N 117810 -360 118320 -360 {lab=1.2V}
N 118560 -820 118600 -820 {lab=#net552}
N 118600 -820 118600 -460 {lab=#net552}
N 118690 -820 118730 -820 {lab=#net553}
N 118690 -820 118690 -460 {lab=#net553}
N 118690 -400 118690 -360 {lab=1.2V}
N 118320 -360 118690 -360 {lab=1.2V}
N 118600 -400 118600 -330 {lab=Vss}
N 118230 -330 118600 -330 {lab=Vss}
N 119190 -960 119190 -850 {lab=Gdrive}
N 119280 -960 119360 -960 {lab=Gdrive}
N 119360 -960 119360 -850 {lab=Gdrive}
N 119190 -790 119190 -700 {lab=Gate[79]}
N 119280 -700 119360 -700 {lab=Gate[79]}
N 119360 -790 119360 -700 {lab=Gate[79]}
N 119500 -790 119500 -650 {lab=Gate[79]}
N 119390 -650 119500 -650 {lab=Gate[79]}
N 119280 -700 119280 -650 {lab=Gate[79]}
N 119190 -700 119280 -700 {lab=Gate[79]}
N 119390 -650 119390 -570 {lab=Gate[79]}
N 119280 -650 119390 -650 {lab=Gate[79]}
N 119440 -820 119460 -820 {lab=ctrl_n[79]}
N 119690 -960 119690 -850 {lab=Ssense}
N 119780 -960 119860 -960 {lab=Ssense}
N 119860 -960 119860 -850 {lab=Ssense}
N 119690 -790 119690 -700 {lab=Source[79]}
N 119780 -700 119860 -700 {lab=Source[79]}
N 119860 -790 119860 -700 {lab=Source[79]}
N 119780 -700 119780 -650 {lab=Source[79]}
N 119690 -700 119780 -700 {lab=Source[79]}
N 120060 -960 120060 -850 {lab=Sforce}
N 120150 -960 120230 -960 {lab=Sforce}
N 120230 -960 120230 -850 {lab=Sforce}
N 120060 -790 120060 -700 {lab=Source[79]}
N 120150 -700 120230 -700 {lab=Source[79]}
N 120230 -790 120230 -700 {lab=Source[79]}
N 120150 -700 120150 -650 {lab=Source[79]}
N 120060 -700 120150 -700 {lab=Source[79]}
N 119960 -650 120150 -650 {lab=Source[79]}
N 120150 -1140 120440 -1140 {lab=Sforce}
N 120150 -1140 120150 -960 {lab=Sforce}
N 120060 -960 120150 -960 {lab=Sforce}
N 119780 -1170 120440 -1170 {lab=Ssense}
N 119780 -1170 119780 -960 {lab=Ssense}
N 119690 -960 119780 -960 {lab=Ssense}
N 119280 -1200 120440 -1200 {lab=Gdrive}
N 119280 -1200 119280 -960 {lab=Gdrive}
N 119190 -960 119280 -960 {lab=Gdrive}
N 119500 -1230 120440 -1230 {lab=Vcl}
N 119500 -1230 119500 -850 {lab=Vcl}
N 119740 -1380 119740 -1350 {lab=ctrl_p[79]}
N 119610 -1350 119740 -1350 {lab=ctrl_p[79]}
N 119110 -1350 119110 -820 {lab=ctrl_p[79]}
N 119110 -820 119150 -820 {lab=ctrl_p[79]}
N 119610 -820 119650 -820 {lab=ctrl_p[79]}
N 119610 -1350 119610 -820 {lab=ctrl_p[79]}
N 119110 -1350 119610 -1350 {lab=ctrl_p[79]}
N 119440 -1320 119440 -820 {lab=ctrl_n[79]}
N 119400 -820 119440 -820 {lab=ctrl_n[79]}
N 119440 -1320 119790 -1320 {lab=ctrl_n[79]}
N 119790 -1380 119790 -1320 {lab=ctrl_n[79]}
N 119900 -820 119940 -820 {lab=ctrl_n[79]}
N 119980 -820 120020 -820 {lab=ctrl_p[79]}
N 119940 -1320 120300 -1320 {lab=ctrl_n[79]}
N 119940 -1320 119940 -820 {lab=ctrl_n[79]}
N 119790 -1320 119940 -1320 {lab=ctrl_n[79]}
N 119740 -1350 119980 -1350 {lab=ctrl_p[79]}
N 119980 -1350 119980 -820 {lab=ctrl_p[79]}
N 120300 -1320 120300 -820 {lab=ctrl_n[79]}
N 120270 -820 120300 -820 {lab=ctrl_n[79]}
N 119960 -650 119960 -580 {lab=Source[79]}
N 119780 -650 119960 -650 {lab=Source[79]}
N 119190 -820 119230 -820 {lab=#net554}
N 119230 -820 119230 -460 {lab=#net554}
N 119500 -820 119540 -820 {lab=#net555}
N 119540 -820 119540 -460 {lab=#net555}
N 119230 -400 119230 -330 {lab=Vss}
N 120100 -330 120400 -330 {lab=Vss}
N 120400 -1080 120400 -330 {lab=Vss}
N 120400 -1080 120440 -1080 {lab=Vss}
N 120370 -1110 120440 -1110 {lab=1.2V}
N 120370 -1110 120370 -360 {lab=1.2V}
N 119540 -400 119540 -330 {lab=Vss}
N 119230 -330 119540 -330 {lab=Vss}
N 120190 -360 120370 -360 {lab=1.2V}
N 119820 -820 119860 -820 {lab=#net556}
N 119820 -820 119820 -460 {lab=#net556}
N 119690 -820 119730 -820 {lab=#net557}
N 119730 -820 119730 -460 {lab=#net557}
N 119820 -400 119820 -360 {lab=1.2V}
N 119730 -400 119730 -330 {lab=Vss}
N 119540 -330 119730 -330 {lab=Vss}
N 119310 -820 119360 -820 {lab=#net558}
N 119310 -820 119310 -460 {lab=#net558}
N 119310 -400 119310 -360 {lab=1.2V}
N 119310 -360 119820 -360 {lab=1.2V}
N 120060 -820 120100 -820 {lab=#net559}
N 120100 -820 120100 -460 {lab=#net559}
N 120190 -820 120230 -820 {lab=#net560}
N 120190 -820 120190 -460 {lab=#net560}
N 120190 -400 120190 -360 {lab=1.2V}
N 119820 -360 120190 -360 {lab=1.2V}
N 120100 -400 120100 -330 {lab=Vss}
N 119730 -330 120100 -330 {lab=Vss}
N -110 -1140 1650 -1140 {lab=Sforce}
N -110 -1170 1280 -1170 {lab=Ssense}
N -110 -1200 780 -1200 {lab=Gdrive}
N -110 -1230 1000 -1230 {lab=Vcl}
N -110 -1080 1900 -1080 {lab=Vss}
N -110 -1110 1870 -1110 {lab=1.2V}
N -190 -1370 -100 -1370 {lab=ctrl_n[0:79]}
N -190 -1400 -100 -1400 {lab=ctrl_p[0:79]}
N -190 -1340 -100 -1340 {lab=Source[0:79]}
N -190 -1310 -100 -1310 {lab=Gate[0:79]}
C {devices/lab_pin.sym} -190 -1400 0 0 {name=lab_ctrl_p_bus lab=ctrl_p[0:79] dir=inout}
C {devices/lab_pin.sym} -190 -1370 0 0 {name=lab_ctrl_n_bus lab=ctrl_n[0:79] dir=inout}
C {devices/lab_pin.sym} -190 -1310 0 0 {name=lab_Gate_bus lab=Gate[0:79] dir=inout}
C {devices/lab_pin.sym} -190 -1340 0 0 {name=lab_Source_bus lab=Source[0:79] dir=inout}
C {devices/iopin.sym} -110 -1230 0 0 {name=p_Vcl lab=Vcl}
C {devices/iopin.sym} -110 -1200 0 0 {name=p_Gdrive lab=Gdrive}
C {devices/iopin.sym} -110 -1170 0 0 {name=p_Ssense lab=Ssense}
C {devices/iopin.sym} -110 -1140 0 0 {name=p_Sforce lab=Sforce}
C {devices/iopin.sym} -110 -1110 0 0 {name=p_1.2V lab=1.2V}
C {devices/iopin.sym} -110 -1080 0 0 {name=p_Vss lab=Vss}
C {sg13g2_pr/sg13_lv_pmos.sym} 880 -820 0 1 {name=M1_00
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 670 -820 0 0 {name=M2_00
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 980 -820 0 0 {name=M3_00
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1380 -820 0 1 {name=M4_00
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1170 -820 0 0 {name=M5_00
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1750 -820 0 1 {name=M6_00
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 1540 -820 0 0 {name=M7_00
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 730 -430 2 0 {name=R1_00
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 810 -430 2 0 {name=R2_00
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 1040 -430 2 0 {name=R3_00
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 1230 -430 2 0 {name=R4_00
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 1320 -430 2 0 {name=R5_00
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 1600 -430 2 0 {name=R6_00
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 1690 -430 2 0 {name=R7_00
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 1240 -1380 0 0 {name=lp_ctrl_p_0__00 lab=ctrl_p[0]}
C {devices/lab_pin.sym} 1290 -1380 0 0 {name=lp_ctrl_n_0__00 lab=ctrl_n[0]}
C {devices/lab_pin.sym} 890 -570 0 0 {name=lp_Gate_0__00 lab=Gate[0]}
C {devices/lab_pin.sym} 1460 -580 0 0 {name=lp_Source_0__00 lab=Source[0]}
C {sg13g2_pr/sg13_lv_pmos.sym} 2380 -820 0 1 {name=M1_01
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2170 -820 0 0 {name=M2_01
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2480 -820 0 0 {name=M3_01
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2880 -820 0 1 {name=M4_01
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2670 -820 0 0 {name=M5_01
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3250 -820 0 1 {name=M6_01
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 3040 -820 0 0 {name=M7_01
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 2230 -430 2 0 {name=R1_01
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 2310 -430 2 0 {name=R2_01
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 2540 -430 2 0 {name=R3_01
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 2730 -430 2 0 {name=R4_01
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 2820 -430 2 0 {name=R5_01
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 3100 -430 2 0 {name=R6_01
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 3190 -430 2 0 {name=R7_01
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 2740 -1380 0 0 {name=lp_ctrl_p_1__01 lab=ctrl_p[1]}
C {devices/lab_pin.sym} 2790 -1380 0 0 {name=lp_ctrl_n_1__01 lab=ctrl_n[1]}
C {devices/lab_pin.sym} 2390 -570 0 0 {name=lp_Gate_1__01 lab=Gate[1]}
C {devices/lab_pin.sym} 2960 -580 0 0 {name=lp_Source_1__01 lab=Source[1]}
C {sg13g2_pr/sg13_lv_pmos.sym} 3880 -820 0 1 {name=M1_02
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3670 -820 0 0 {name=M2_02
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3980 -820 0 0 {name=M3_02
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4380 -820 0 1 {name=M4_02
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4170 -820 0 0 {name=M5_02
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4750 -820 0 1 {name=M6_02
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 4540 -820 0 0 {name=M7_02
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 3730 -430 2 0 {name=R1_02
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 3810 -430 2 0 {name=R2_02
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 4040 -430 2 0 {name=R3_02
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 4230 -430 2 0 {name=R4_02
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 4320 -430 2 0 {name=R5_02
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 4600 -430 2 0 {name=R6_02
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 4690 -430 2 0 {name=R7_02
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 4240 -1380 0 0 {name=lp_ctrl_p_2__02 lab=ctrl_p[2]}
C {devices/lab_pin.sym} 4290 -1380 0 0 {name=lp_ctrl_n_2__02 lab=ctrl_n[2]}
C {devices/lab_pin.sym} 3890 -570 0 0 {name=lp_Gate_2__02 lab=Gate[2]}
C {devices/lab_pin.sym} 4460 -580 0 0 {name=lp_Source_2__02 lab=Source[2]}
C {sg13g2_pr/sg13_lv_pmos.sym} 5380 -820 0 1 {name=M1_03
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5170 -820 0 0 {name=M2_03
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5480 -820 0 0 {name=M3_03
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5880 -820 0 1 {name=M4_03
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5670 -820 0 0 {name=M5_03
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6250 -820 0 1 {name=M6_03
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 6040 -820 0 0 {name=M7_03
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 5230 -430 2 0 {name=R1_03
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 5310 -430 2 0 {name=R2_03
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 5540 -430 2 0 {name=R3_03
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 5730 -430 2 0 {name=R4_03
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 5820 -430 2 0 {name=R5_03
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 6100 -430 2 0 {name=R6_03
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 6190 -430 2 0 {name=R7_03
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 5740 -1380 0 0 {name=lp_ctrl_p_3__03 lab=ctrl_p[3]}
C {devices/lab_pin.sym} 5790 -1380 0 0 {name=lp_ctrl_n_3__03 lab=ctrl_n[3]}
C {devices/lab_pin.sym} 5390 -570 0 0 {name=lp_Gate_3__03 lab=Gate[3]}
C {devices/lab_pin.sym} 5960 -580 0 0 {name=lp_Source_3__03 lab=Source[3]}
C {sg13g2_pr/sg13_lv_pmos.sym} 6880 -820 0 1 {name=M1_04
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6670 -820 0 0 {name=M2_04
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6980 -820 0 0 {name=M3_04
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7380 -820 0 1 {name=M4_04
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7170 -820 0 0 {name=M5_04
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7750 -820 0 1 {name=M6_04
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 7540 -820 0 0 {name=M7_04
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 6730 -430 2 0 {name=R1_04
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 6810 -430 2 0 {name=R2_04
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 7040 -430 2 0 {name=R3_04
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 7230 -430 2 0 {name=R4_04
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 7320 -430 2 0 {name=R5_04
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 7600 -430 2 0 {name=R6_04
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 7690 -430 2 0 {name=R7_04
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 7240 -1380 0 0 {name=lp_ctrl_p_4__04 lab=ctrl_p[4]}
C {devices/lab_pin.sym} 7290 -1380 0 0 {name=lp_ctrl_n_4__04 lab=ctrl_n[4]}
C {devices/lab_pin.sym} 6890 -570 0 0 {name=lp_Gate_4__04 lab=Gate[4]}
C {devices/lab_pin.sym} 7460 -580 0 0 {name=lp_Source_4__04 lab=Source[4]}
C {sg13g2_pr/sg13_lv_pmos.sym} 8380 -820 0 1 {name=M1_05
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8170 -820 0 0 {name=M2_05
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8480 -820 0 0 {name=M3_05
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8880 -820 0 1 {name=M4_05
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8670 -820 0 0 {name=M5_05
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9250 -820 0 1 {name=M6_05
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 9040 -820 0 0 {name=M7_05
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 8230 -430 2 0 {name=R1_05
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 8310 -430 2 0 {name=R2_05
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 8540 -430 2 0 {name=R3_05
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 8730 -430 2 0 {name=R4_05
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 8820 -430 2 0 {name=R5_05
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 9100 -430 2 0 {name=R6_05
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 9190 -430 2 0 {name=R7_05
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 8740 -1380 0 0 {name=lp_ctrl_p_5__05 lab=ctrl_p[5]}
C {devices/lab_pin.sym} 8790 -1380 0 0 {name=lp_ctrl_n_5__05 lab=ctrl_n[5]}
C {devices/lab_pin.sym} 8390 -570 0 0 {name=lp_Gate_5__05 lab=Gate[5]}
C {devices/lab_pin.sym} 8960 -580 0 0 {name=lp_Source_5__05 lab=Source[5]}
C {sg13g2_pr/sg13_lv_pmos.sym} 9880 -820 0 1 {name=M1_06
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9670 -820 0 0 {name=M2_06
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 9980 -820 0 0 {name=M3_06
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10380 -820 0 1 {name=M4_06
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 10170 -820 0 0 {name=M5_06
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10750 -820 0 1 {name=M6_06
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 10540 -820 0 0 {name=M7_06
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 9730 -430 2 0 {name=R1_06
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 9810 -430 2 0 {name=R2_06
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 10040 -430 2 0 {name=R3_06
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 10230 -430 2 0 {name=R4_06
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 10320 -430 2 0 {name=R5_06
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 10600 -430 2 0 {name=R6_06
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 10690 -430 2 0 {name=R7_06
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 10240 -1380 0 0 {name=lp_ctrl_p_6__06 lab=ctrl_p[6]}
C {devices/lab_pin.sym} 10290 -1380 0 0 {name=lp_ctrl_n_6__06 lab=ctrl_n[6]}
C {devices/lab_pin.sym} 9890 -570 0 0 {name=lp_Gate_6__06 lab=Gate[6]}
C {devices/lab_pin.sym} 10460 -580 0 0 {name=lp_Source_6__06 lab=Source[6]}
C {sg13g2_pr/sg13_lv_pmos.sym} 11380 -820 0 1 {name=M1_07
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11170 -820 0 0 {name=M2_07
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11480 -820 0 0 {name=M3_07
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11880 -820 0 1 {name=M4_07
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11670 -820 0 0 {name=M5_07
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12250 -820 0 1 {name=M6_07
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 12040 -820 0 0 {name=M7_07
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 11230 -430 2 0 {name=R1_07
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 11310 -430 2 0 {name=R2_07
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 11540 -430 2 0 {name=R3_07
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 11730 -430 2 0 {name=R4_07
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 11820 -430 2 0 {name=R5_07
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 12100 -430 2 0 {name=R6_07
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 12190 -430 2 0 {name=R7_07
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 11740 -1380 0 0 {name=lp_ctrl_p_7__07 lab=ctrl_p[7]}
C {devices/lab_pin.sym} 11790 -1380 0 0 {name=lp_ctrl_n_7__07 lab=ctrl_n[7]}
C {devices/lab_pin.sym} 11390 -570 0 0 {name=lp_Gate_7__07 lab=Gate[7]}
C {devices/lab_pin.sym} 11960 -580 0 0 {name=lp_Source_7__07 lab=Source[7]}
C {sg13g2_pr/sg13_lv_pmos.sym} 12880 -820 0 1 {name=M1_08
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12670 -820 0 0 {name=M2_08
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12980 -820 0 0 {name=M3_08
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13380 -820 0 1 {name=M4_08
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13170 -820 0 0 {name=M5_08
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13750 -820 0 1 {name=M6_08
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 13540 -820 0 0 {name=M7_08
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 12730 -430 2 0 {name=R1_08
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 12810 -430 2 0 {name=R2_08
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 13040 -430 2 0 {name=R3_08
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 13230 -430 2 0 {name=R4_08
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 13320 -430 2 0 {name=R5_08
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 13600 -430 2 0 {name=R6_08
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 13690 -430 2 0 {name=R7_08
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 13240 -1380 0 0 {name=lp_ctrl_p_8__08 lab=ctrl_p[8]}
C {devices/lab_pin.sym} 13290 -1380 0 0 {name=lp_ctrl_n_8__08 lab=ctrl_n[8]}
C {devices/lab_pin.sym} 12890 -570 0 0 {name=lp_Gate_8__08 lab=Gate[8]}
C {devices/lab_pin.sym} 13460 -580 0 0 {name=lp_Source_8__08 lab=Source[8]}
C {sg13g2_pr/sg13_lv_pmos.sym} 14380 -820 0 1 {name=M1_09
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14170 -820 0 0 {name=M2_09
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14480 -820 0 0 {name=M3_09
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 14880 -820 0 1 {name=M4_09
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 14670 -820 0 0 {name=M5_09
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 15250 -820 0 1 {name=M6_09
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 15040 -820 0 0 {name=M7_09
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 14230 -430 2 0 {name=R1_09
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 14310 -430 2 0 {name=R2_09
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 14540 -430 2 0 {name=R3_09
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 14730 -430 2 0 {name=R4_09
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 14820 -430 2 0 {name=R5_09
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 15100 -430 2 0 {name=R6_09
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 15190 -430 2 0 {name=R7_09
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 14740 -1380 0 0 {name=lp_ctrl_p_9__09 lab=ctrl_p[9]}
C {devices/lab_pin.sym} 14790 -1380 0 0 {name=lp_ctrl_n_9__09 lab=ctrl_n[9]}
C {devices/lab_pin.sym} 14390 -570 0 0 {name=lp_Gate_9__09 lab=Gate[9]}
C {devices/lab_pin.sym} 14960 -580 0 0 {name=lp_Source_9__09 lab=Source[9]}
C {sg13g2_pr/sg13_lv_pmos.sym} 15880 -820 0 1 {name=M1_10
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15670 -820 0 0 {name=M2_10
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 15980 -820 0 0 {name=M3_10
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16380 -820 0 1 {name=M4_10
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 16170 -820 0 0 {name=M5_10
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 16750 -820 0 1 {name=M6_10
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 16540 -820 0 0 {name=M7_10
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 15730 -430 2 0 {name=R1_10
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 15810 -430 2 0 {name=R2_10
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 16040 -430 2 0 {name=R3_10
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 16230 -430 2 0 {name=R4_10
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 16320 -430 2 0 {name=R5_10
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 16600 -430 2 0 {name=R6_10
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 16690 -430 2 0 {name=R7_10
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 16240 -1380 0 0 {name=lp_ctrl_p_10__10 lab=ctrl_p[10]}
C {devices/lab_pin.sym} 16290 -1380 0 0 {name=lp_ctrl_n_10__10 lab=ctrl_n[10]}
C {devices/lab_pin.sym} 15890 -570 0 0 {name=lp_Gate_10__10 lab=Gate[10]}
C {devices/lab_pin.sym} 16460 -580 0 0 {name=lp_Source_10__10 lab=Source[10]}
C {sg13g2_pr/sg13_lv_pmos.sym} 17380 -820 0 1 {name=M1_11
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 17170 -820 0 0 {name=M2_11
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 17480 -820 0 0 {name=M3_11
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 17880 -820 0 1 {name=M4_11
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 17670 -820 0 0 {name=M5_11
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 18250 -820 0 1 {name=M6_11
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 18040 -820 0 0 {name=M7_11
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 17230 -430 2 0 {name=R1_11
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 17310 -430 2 0 {name=R2_11
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 17540 -430 2 0 {name=R3_11
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 17730 -430 2 0 {name=R4_11
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 17820 -430 2 0 {name=R5_11
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 18100 -430 2 0 {name=R6_11
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 18190 -430 2 0 {name=R7_11
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 17740 -1380 0 0 {name=lp_ctrl_p_11__11 lab=ctrl_p[11]}
C {devices/lab_pin.sym} 17790 -1380 0 0 {name=lp_ctrl_n_11__11 lab=ctrl_n[11]}
C {devices/lab_pin.sym} 17390 -570 0 0 {name=lp_Gate_11__11 lab=Gate[11]}
C {devices/lab_pin.sym} 17960 -580 0 0 {name=lp_Source_11__11 lab=Source[11]}
C {sg13g2_pr/sg13_lv_pmos.sym} 18880 -820 0 1 {name=M1_12
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 18670 -820 0 0 {name=M2_12
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 18980 -820 0 0 {name=M3_12
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 19380 -820 0 1 {name=M4_12
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 19170 -820 0 0 {name=M5_12
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 19750 -820 0 1 {name=M6_12
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 19540 -820 0 0 {name=M7_12
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 18730 -430 2 0 {name=R1_12
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 18810 -430 2 0 {name=R2_12
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 19040 -430 2 0 {name=R3_12
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 19230 -430 2 0 {name=R4_12
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 19320 -430 2 0 {name=R5_12
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 19600 -430 2 0 {name=R6_12
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 19690 -430 2 0 {name=R7_12
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 19240 -1380 0 0 {name=lp_ctrl_p_12__12 lab=ctrl_p[12]}
C {devices/lab_pin.sym} 19290 -1380 0 0 {name=lp_ctrl_n_12__12 lab=ctrl_n[12]}
C {devices/lab_pin.sym} 18890 -570 0 0 {name=lp_Gate_12__12 lab=Gate[12]}
C {devices/lab_pin.sym} 19460 -580 0 0 {name=lp_Source_12__12 lab=Source[12]}
C {sg13g2_pr/sg13_lv_pmos.sym} 20380 -820 0 1 {name=M1_13
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 20170 -820 0 0 {name=M2_13
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 20480 -820 0 0 {name=M3_13
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 20880 -820 0 1 {name=M4_13
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 20670 -820 0 0 {name=M5_13
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 21250 -820 0 1 {name=M6_13
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 21040 -820 0 0 {name=M7_13
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 20230 -430 2 0 {name=R1_13
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 20310 -430 2 0 {name=R2_13
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 20540 -430 2 0 {name=R3_13
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 20730 -430 2 0 {name=R4_13
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 20820 -430 2 0 {name=R5_13
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 21100 -430 2 0 {name=R6_13
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 21190 -430 2 0 {name=R7_13
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 20740 -1380 0 0 {name=lp_ctrl_p_13__13 lab=ctrl_p[13]}
C {devices/lab_pin.sym} 20790 -1380 0 0 {name=lp_ctrl_n_13__13 lab=ctrl_n[13]}
C {devices/lab_pin.sym} 20390 -570 0 0 {name=lp_Gate_13__13 lab=Gate[13]}
C {devices/lab_pin.sym} 20960 -580 0 0 {name=lp_Source_13__13 lab=Source[13]}
C {sg13g2_pr/sg13_lv_pmos.sym} 21880 -820 0 1 {name=M1_14
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 21670 -820 0 0 {name=M2_14
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 21980 -820 0 0 {name=M3_14
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 22380 -820 0 1 {name=M4_14
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 22170 -820 0 0 {name=M5_14
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 22750 -820 0 1 {name=M6_14
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 22540 -820 0 0 {name=M7_14
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 21730 -430 2 0 {name=R1_14
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 21810 -430 2 0 {name=R2_14
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 22040 -430 2 0 {name=R3_14
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 22230 -430 2 0 {name=R4_14
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 22320 -430 2 0 {name=R5_14
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 22600 -430 2 0 {name=R6_14
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 22690 -430 2 0 {name=R7_14
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 22240 -1380 0 0 {name=lp_ctrl_p_14__14 lab=ctrl_p[14]}
C {devices/lab_pin.sym} 22290 -1380 0 0 {name=lp_ctrl_n_14__14 lab=ctrl_n[14]}
C {devices/lab_pin.sym} 21890 -570 0 0 {name=lp_Gate_14__14 lab=Gate[14]}
C {devices/lab_pin.sym} 22460 -580 0 0 {name=lp_Source_14__14 lab=Source[14]}
C {sg13g2_pr/sg13_lv_pmos.sym} 23380 -820 0 1 {name=M1_15
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 23170 -820 0 0 {name=M2_15
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 23480 -820 0 0 {name=M3_15
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 23880 -820 0 1 {name=M4_15
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 23670 -820 0 0 {name=M5_15
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 24250 -820 0 1 {name=M6_15
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 24040 -820 0 0 {name=M7_15
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 23230 -430 2 0 {name=R1_15
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 23310 -430 2 0 {name=R2_15
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 23540 -430 2 0 {name=R3_15
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 23730 -430 2 0 {name=R4_15
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 23820 -430 2 0 {name=R5_15
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 24100 -430 2 0 {name=R6_15
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 24190 -430 2 0 {name=R7_15
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 23740 -1380 0 0 {name=lp_ctrl_p_15__15 lab=ctrl_p[15]}
C {devices/lab_pin.sym} 23790 -1380 0 0 {name=lp_ctrl_n_15__15 lab=ctrl_n[15]}
C {devices/lab_pin.sym} 23390 -570 0 0 {name=lp_Gate_15__15 lab=Gate[15]}
C {devices/lab_pin.sym} 23960 -580 0 0 {name=lp_Source_15__15 lab=Source[15]}
C {sg13g2_pr/sg13_lv_pmos.sym} 24880 -820 0 1 {name=M1_16
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 24670 -820 0 0 {name=M2_16
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 24980 -820 0 0 {name=M3_16
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 25380 -820 0 1 {name=M4_16
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 25170 -820 0 0 {name=M5_16
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 25750 -820 0 1 {name=M6_16
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 25540 -820 0 0 {name=M7_16
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 24730 -430 2 0 {name=R1_16
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 24810 -430 2 0 {name=R2_16
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 25040 -430 2 0 {name=R3_16
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 25230 -430 2 0 {name=R4_16
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 25320 -430 2 0 {name=R5_16
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 25600 -430 2 0 {name=R6_16
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 25690 -430 2 0 {name=R7_16
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 25240 -1380 0 0 {name=lp_ctrl_p_16__16 lab=ctrl_p[16]}
C {devices/lab_pin.sym} 25290 -1380 0 0 {name=lp_ctrl_n_16__16 lab=ctrl_n[16]}
C {devices/lab_pin.sym} 24890 -570 0 0 {name=lp_Gate_16__16 lab=Gate[16]}
C {devices/lab_pin.sym} 25460 -580 0 0 {name=lp_Source_16__16 lab=Source[16]}
C {sg13g2_pr/sg13_lv_pmos.sym} 26380 -820 0 1 {name=M1_17
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 26170 -820 0 0 {name=M2_17
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 26480 -820 0 0 {name=M3_17
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 26880 -820 0 1 {name=M4_17
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 26670 -820 0 0 {name=M5_17
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 27250 -820 0 1 {name=M6_17
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 27040 -820 0 0 {name=M7_17
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 26230 -430 2 0 {name=R1_17
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 26310 -430 2 0 {name=R2_17
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 26540 -430 2 0 {name=R3_17
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 26730 -430 2 0 {name=R4_17
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 26820 -430 2 0 {name=R5_17
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 27100 -430 2 0 {name=R6_17
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 27190 -430 2 0 {name=R7_17
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 26740 -1380 0 0 {name=lp_ctrl_p_17__17 lab=ctrl_p[17]}
C {devices/lab_pin.sym} 26790 -1380 0 0 {name=lp_ctrl_n_17__17 lab=ctrl_n[17]}
C {devices/lab_pin.sym} 26390 -570 0 0 {name=lp_Gate_17__17 lab=Gate[17]}
C {devices/lab_pin.sym} 26960 -580 0 0 {name=lp_Source_17__17 lab=Source[17]}
C {sg13g2_pr/sg13_lv_pmos.sym} 27880 -820 0 1 {name=M1_18
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 27670 -820 0 0 {name=M2_18
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 27980 -820 0 0 {name=M3_18
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 28380 -820 0 1 {name=M4_18
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 28170 -820 0 0 {name=M5_18
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 28750 -820 0 1 {name=M6_18
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 28540 -820 0 0 {name=M7_18
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 27730 -430 2 0 {name=R1_18
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 27810 -430 2 0 {name=R2_18
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 28040 -430 2 0 {name=R3_18
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 28230 -430 2 0 {name=R4_18
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 28320 -430 2 0 {name=R5_18
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 28600 -430 2 0 {name=R6_18
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 28690 -430 2 0 {name=R7_18
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 28240 -1380 0 0 {name=lp_ctrl_p_18__18 lab=ctrl_p[18]}
C {devices/lab_pin.sym} 28290 -1380 0 0 {name=lp_ctrl_n_18__18 lab=ctrl_n[18]}
C {devices/lab_pin.sym} 27890 -570 0 0 {name=lp_Gate_18__18 lab=Gate[18]}
C {devices/lab_pin.sym} 28460 -580 0 0 {name=lp_Source_18__18 lab=Source[18]}
C {sg13g2_pr/sg13_lv_pmos.sym} 29380 -820 0 1 {name=M1_19
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 29170 -820 0 0 {name=M2_19
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 29480 -820 0 0 {name=M3_19
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 29880 -820 0 1 {name=M4_19
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 29670 -820 0 0 {name=M5_19
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 30250 -820 0 1 {name=M6_19
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 30040 -820 0 0 {name=M7_19
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 29230 -430 2 0 {name=R1_19
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 29310 -430 2 0 {name=R2_19
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 29540 -430 2 0 {name=R3_19
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 29730 -430 2 0 {name=R4_19
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 29820 -430 2 0 {name=R5_19
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 30100 -430 2 0 {name=R6_19
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 30190 -430 2 0 {name=R7_19
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 29740 -1380 0 0 {name=lp_ctrl_p_19__19 lab=ctrl_p[19]}
C {devices/lab_pin.sym} 29790 -1380 0 0 {name=lp_ctrl_n_19__19 lab=ctrl_n[19]}
C {devices/lab_pin.sym} 29390 -570 0 0 {name=lp_Gate_19__19 lab=Gate[19]}
C {devices/lab_pin.sym} 29960 -580 0 0 {name=lp_Source_19__19 lab=Source[19]}
C {sg13g2_pr/sg13_lv_pmos.sym} 30880 -820 0 1 {name=M1_20
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 30670 -820 0 0 {name=M2_20
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 30980 -820 0 0 {name=M3_20
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 31380 -820 0 1 {name=M4_20
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 31170 -820 0 0 {name=M5_20
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 31750 -820 0 1 {name=M6_20
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 31540 -820 0 0 {name=M7_20
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 30730 -430 2 0 {name=R1_20
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 30810 -430 2 0 {name=R2_20
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 31040 -430 2 0 {name=R3_20
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 31230 -430 2 0 {name=R4_20
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 31320 -430 2 0 {name=R5_20
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 31600 -430 2 0 {name=R6_20
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 31690 -430 2 0 {name=R7_20
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 31240 -1380 0 0 {name=lp_ctrl_p_20__20 lab=ctrl_p[20]}
C {devices/lab_pin.sym} 31290 -1380 0 0 {name=lp_ctrl_n_20__20 lab=ctrl_n[20]}
C {devices/lab_pin.sym} 30890 -570 0 0 {name=lp_Gate_20__20 lab=Gate[20]}
C {devices/lab_pin.sym} 31460 -580 0 0 {name=lp_Source_20__20 lab=Source[20]}
C {sg13g2_pr/sg13_lv_pmos.sym} 32380 -820 0 1 {name=M1_21
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 32170 -820 0 0 {name=M2_21
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 32480 -820 0 0 {name=M3_21
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 32880 -820 0 1 {name=M4_21
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 32670 -820 0 0 {name=M5_21
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 33250 -820 0 1 {name=M6_21
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 33040 -820 0 0 {name=M7_21
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 32230 -430 2 0 {name=R1_21
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 32310 -430 2 0 {name=R2_21
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 32540 -430 2 0 {name=R3_21
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 32730 -430 2 0 {name=R4_21
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 32820 -430 2 0 {name=R5_21
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 33100 -430 2 0 {name=R6_21
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 33190 -430 2 0 {name=R7_21
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 32740 -1380 0 0 {name=lp_ctrl_p_21__21 lab=ctrl_p[21]}
C {devices/lab_pin.sym} 32790 -1380 0 0 {name=lp_ctrl_n_21__21 lab=ctrl_n[21]}
C {devices/lab_pin.sym} 32390 -570 0 0 {name=lp_Gate_21__21 lab=Gate[21]}
C {devices/lab_pin.sym} 32960 -580 0 0 {name=lp_Source_21__21 lab=Source[21]}
C {sg13g2_pr/sg13_lv_pmos.sym} 33880 -820 0 1 {name=M1_22
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 33670 -820 0 0 {name=M2_22
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 33980 -820 0 0 {name=M3_22
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 34380 -820 0 1 {name=M4_22
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 34170 -820 0 0 {name=M5_22
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 34750 -820 0 1 {name=M6_22
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 34540 -820 0 0 {name=M7_22
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 33730 -430 2 0 {name=R1_22
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 33810 -430 2 0 {name=R2_22
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 34040 -430 2 0 {name=R3_22
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 34230 -430 2 0 {name=R4_22
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 34320 -430 2 0 {name=R5_22
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 34600 -430 2 0 {name=R6_22
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 34690 -430 2 0 {name=R7_22
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 34240 -1380 0 0 {name=lp_ctrl_p_22__22 lab=ctrl_p[22]}
C {devices/lab_pin.sym} 34290 -1380 0 0 {name=lp_ctrl_n_22__22 lab=ctrl_n[22]}
C {devices/lab_pin.sym} 33890 -570 0 0 {name=lp_Gate_22__22 lab=Gate[22]}
C {devices/lab_pin.sym} 34460 -580 0 0 {name=lp_Source_22__22 lab=Source[22]}
C {sg13g2_pr/sg13_lv_pmos.sym} 35380 -820 0 1 {name=M1_23
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 35170 -820 0 0 {name=M2_23
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 35480 -820 0 0 {name=M3_23
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 35880 -820 0 1 {name=M4_23
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 35670 -820 0 0 {name=M5_23
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 36250 -820 0 1 {name=M6_23
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 36040 -820 0 0 {name=M7_23
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 35230 -430 2 0 {name=R1_23
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 35310 -430 2 0 {name=R2_23
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 35540 -430 2 0 {name=R3_23
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 35730 -430 2 0 {name=R4_23
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 35820 -430 2 0 {name=R5_23
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 36100 -430 2 0 {name=R6_23
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 36190 -430 2 0 {name=R7_23
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 35740 -1380 0 0 {name=lp_ctrl_p_23__23 lab=ctrl_p[23]}
C {devices/lab_pin.sym} 35790 -1380 0 0 {name=lp_ctrl_n_23__23 lab=ctrl_n[23]}
C {devices/lab_pin.sym} 35390 -570 0 0 {name=lp_Gate_23__23 lab=Gate[23]}
C {devices/lab_pin.sym} 35960 -580 0 0 {name=lp_Source_23__23 lab=Source[23]}
C {sg13g2_pr/sg13_lv_pmos.sym} 36880 -820 0 1 {name=M1_24
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 36670 -820 0 0 {name=M2_24
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 36980 -820 0 0 {name=M3_24
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 37380 -820 0 1 {name=M4_24
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 37170 -820 0 0 {name=M5_24
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 37750 -820 0 1 {name=M6_24
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 37540 -820 0 0 {name=M7_24
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 36730 -430 2 0 {name=R1_24
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 36810 -430 2 0 {name=R2_24
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 37040 -430 2 0 {name=R3_24
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 37230 -430 2 0 {name=R4_24
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 37320 -430 2 0 {name=R5_24
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 37600 -430 2 0 {name=R6_24
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 37690 -430 2 0 {name=R7_24
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 37240 -1380 0 0 {name=lp_ctrl_p_24__24 lab=ctrl_p[24]}
C {devices/lab_pin.sym} 37290 -1380 0 0 {name=lp_ctrl_n_24__24 lab=ctrl_n[24]}
C {devices/lab_pin.sym} 36890 -570 0 0 {name=lp_Gate_24__24 lab=Gate[24]}
C {devices/lab_pin.sym} 37460 -580 0 0 {name=lp_Source_24__24 lab=Source[24]}
C {sg13g2_pr/sg13_lv_pmos.sym} 38380 -820 0 1 {name=M1_25
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 38170 -820 0 0 {name=M2_25
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 38480 -820 0 0 {name=M3_25
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 38880 -820 0 1 {name=M4_25
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 38670 -820 0 0 {name=M5_25
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 39250 -820 0 1 {name=M6_25
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 39040 -820 0 0 {name=M7_25
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 38230 -430 2 0 {name=R1_25
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 38310 -430 2 0 {name=R2_25
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 38540 -430 2 0 {name=R3_25
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 38730 -430 2 0 {name=R4_25
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 38820 -430 2 0 {name=R5_25
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 39100 -430 2 0 {name=R6_25
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 39190 -430 2 0 {name=R7_25
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 38740 -1380 0 0 {name=lp_ctrl_p_25__25 lab=ctrl_p[25]}
C {devices/lab_pin.sym} 38790 -1380 0 0 {name=lp_ctrl_n_25__25 lab=ctrl_n[25]}
C {devices/lab_pin.sym} 38390 -570 0 0 {name=lp_Gate_25__25 lab=Gate[25]}
C {devices/lab_pin.sym} 38960 -580 0 0 {name=lp_Source_25__25 lab=Source[25]}
C {sg13g2_pr/sg13_lv_pmos.sym} 39880 -820 0 1 {name=M1_26
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 39670 -820 0 0 {name=M2_26
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 39980 -820 0 0 {name=M3_26
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 40380 -820 0 1 {name=M4_26
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 40170 -820 0 0 {name=M5_26
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 40750 -820 0 1 {name=M6_26
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 40540 -820 0 0 {name=M7_26
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 39730 -430 2 0 {name=R1_26
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 39810 -430 2 0 {name=R2_26
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 40040 -430 2 0 {name=R3_26
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 40230 -430 2 0 {name=R4_26
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 40320 -430 2 0 {name=R5_26
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 40600 -430 2 0 {name=R6_26
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 40690 -430 2 0 {name=R7_26
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 40240 -1380 0 0 {name=lp_ctrl_p_26__26 lab=ctrl_p[26]}
C {devices/lab_pin.sym} 40290 -1380 0 0 {name=lp_ctrl_n_26__26 lab=ctrl_n[26]}
C {devices/lab_pin.sym} 39890 -570 0 0 {name=lp_Gate_26__26 lab=Gate[26]}
C {devices/lab_pin.sym} 40460 -580 0 0 {name=lp_Source_26__26 lab=Source[26]}
C {sg13g2_pr/sg13_lv_pmos.sym} 41380 -820 0 1 {name=M1_27
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 41170 -820 0 0 {name=M2_27
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 41480 -820 0 0 {name=M3_27
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 41880 -820 0 1 {name=M4_27
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 41670 -820 0 0 {name=M5_27
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 42250 -820 0 1 {name=M6_27
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 42040 -820 0 0 {name=M7_27
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 41230 -430 2 0 {name=R1_27
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 41310 -430 2 0 {name=R2_27
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 41540 -430 2 0 {name=R3_27
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 41730 -430 2 0 {name=R4_27
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 41820 -430 2 0 {name=R5_27
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 42100 -430 2 0 {name=R6_27
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 42190 -430 2 0 {name=R7_27
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 41740 -1380 0 0 {name=lp_ctrl_p_27__27 lab=ctrl_p[27]}
C {devices/lab_pin.sym} 41790 -1380 0 0 {name=lp_ctrl_n_27__27 lab=ctrl_n[27]}
C {devices/lab_pin.sym} 41390 -570 0 0 {name=lp_Gate_27__27 lab=Gate[27]}
C {devices/lab_pin.sym} 41960 -580 0 0 {name=lp_Source_27__27 lab=Source[27]}
C {sg13g2_pr/sg13_lv_pmos.sym} 42880 -820 0 1 {name=M1_28
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 42670 -820 0 0 {name=M2_28
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 42980 -820 0 0 {name=M3_28
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 43380 -820 0 1 {name=M4_28
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 43170 -820 0 0 {name=M5_28
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 43750 -820 0 1 {name=M6_28
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 43540 -820 0 0 {name=M7_28
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 42730 -430 2 0 {name=R1_28
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 42810 -430 2 0 {name=R2_28
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 43040 -430 2 0 {name=R3_28
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 43230 -430 2 0 {name=R4_28
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 43320 -430 2 0 {name=R5_28
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 43600 -430 2 0 {name=R6_28
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 43690 -430 2 0 {name=R7_28
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 43240 -1380 0 0 {name=lp_ctrl_p_28__28 lab=ctrl_p[28]}
C {devices/lab_pin.sym} 43290 -1380 0 0 {name=lp_ctrl_n_28__28 lab=ctrl_n[28]}
C {devices/lab_pin.sym} 42890 -570 0 0 {name=lp_Gate_28__28 lab=Gate[28]}
C {devices/lab_pin.sym} 43460 -580 0 0 {name=lp_Source_28__28 lab=Source[28]}
C {sg13g2_pr/sg13_lv_pmos.sym} 44380 -820 0 1 {name=M1_29
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 44170 -820 0 0 {name=M2_29
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 44480 -820 0 0 {name=M3_29
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 44880 -820 0 1 {name=M4_29
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 44670 -820 0 0 {name=M5_29
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 45250 -820 0 1 {name=M6_29
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 45040 -820 0 0 {name=M7_29
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 44230 -430 2 0 {name=R1_29
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 44310 -430 2 0 {name=R2_29
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 44540 -430 2 0 {name=R3_29
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 44730 -430 2 0 {name=R4_29
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 44820 -430 2 0 {name=R5_29
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 45100 -430 2 0 {name=R6_29
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 45190 -430 2 0 {name=R7_29
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 44740 -1380 0 0 {name=lp_ctrl_p_29__29 lab=ctrl_p[29]}
C {devices/lab_pin.sym} 44790 -1380 0 0 {name=lp_ctrl_n_29__29 lab=ctrl_n[29]}
C {devices/lab_pin.sym} 44390 -570 0 0 {name=lp_Gate_29__29 lab=Gate[29]}
C {devices/lab_pin.sym} 44960 -580 0 0 {name=lp_Source_29__29 lab=Source[29]}
C {sg13g2_pr/sg13_lv_pmos.sym} 45880 -820 0 1 {name=M1_30
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 45670 -820 0 0 {name=M2_30
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 45980 -820 0 0 {name=M3_30
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 46380 -820 0 1 {name=M4_30
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 46170 -820 0 0 {name=M5_30
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 46750 -820 0 1 {name=M6_30
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 46540 -820 0 0 {name=M7_30
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 45730 -430 2 0 {name=R1_30
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 45810 -430 2 0 {name=R2_30
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 46040 -430 2 0 {name=R3_30
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 46230 -430 2 0 {name=R4_30
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 46320 -430 2 0 {name=R5_30
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 46600 -430 2 0 {name=R6_30
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 46690 -430 2 0 {name=R7_30
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 46240 -1380 0 0 {name=lp_ctrl_p_30__30 lab=ctrl_p[30]}
C {devices/lab_pin.sym} 46290 -1380 0 0 {name=lp_ctrl_n_30__30 lab=ctrl_n[30]}
C {devices/lab_pin.sym} 45890 -570 0 0 {name=lp_Gate_30__30 lab=Gate[30]}
C {devices/lab_pin.sym} 46460 -580 0 0 {name=lp_Source_30__30 lab=Source[30]}
C {sg13g2_pr/sg13_lv_pmos.sym} 47380 -820 0 1 {name=M1_31
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 47170 -820 0 0 {name=M2_31
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 47480 -820 0 0 {name=M3_31
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 47880 -820 0 1 {name=M4_31
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 47670 -820 0 0 {name=M5_31
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 48250 -820 0 1 {name=M6_31
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 48040 -820 0 0 {name=M7_31
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 47230 -430 2 0 {name=R1_31
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 47310 -430 2 0 {name=R2_31
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 47540 -430 2 0 {name=R3_31
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 47730 -430 2 0 {name=R4_31
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 47820 -430 2 0 {name=R5_31
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 48100 -430 2 0 {name=R6_31
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 48190 -430 2 0 {name=R7_31
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 47740 -1380 0 0 {name=lp_ctrl_p_31__31 lab=ctrl_p[31]}
C {devices/lab_pin.sym} 47790 -1380 0 0 {name=lp_ctrl_n_31__31 lab=ctrl_n[31]}
C {devices/lab_pin.sym} 47390 -570 0 0 {name=lp_Gate_31__31 lab=Gate[31]}
C {devices/lab_pin.sym} 47960 -580 0 0 {name=lp_Source_31__31 lab=Source[31]}
C {sg13g2_pr/sg13_lv_pmos.sym} 48880 -820 0 1 {name=M1_32
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 48670 -820 0 0 {name=M2_32
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 48980 -820 0 0 {name=M3_32
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 49380 -820 0 1 {name=M4_32
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 49170 -820 0 0 {name=M5_32
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 49750 -820 0 1 {name=M6_32
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 49540 -820 0 0 {name=M7_32
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 48730 -430 2 0 {name=R1_32
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 48810 -430 2 0 {name=R2_32
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 49040 -430 2 0 {name=R3_32
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 49230 -430 2 0 {name=R4_32
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 49320 -430 2 0 {name=R5_32
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 49600 -430 2 0 {name=R6_32
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 49690 -430 2 0 {name=R7_32
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 49240 -1380 0 0 {name=lp_ctrl_p_32__32 lab=ctrl_p[32]}
C {devices/lab_pin.sym} 49290 -1380 0 0 {name=lp_ctrl_n_32__32 lab=ctrl_n[32]}
C {devices/lab_pin.sym} 48890 -570 0 0 {name=lp_Gate_32__32 lab=Gate[32]}
C {devices/lab_pin.sym} 49460 -580 0 0 {name=lp_Source_32__32 lab=Source[32]}
C {sg13g2_pr/sg13_lv_pmos.sym} 50380 -820 0 1 {name=M1_33
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 50170 -820 0 0 {name=M2_33
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 50480 -820 0 0 {name=M3_33
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 50880 -820 0 1 {name=M4_33
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 50670 -820 0 0 {name=M5_33
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 51250 -820 0 1 {name=M6_33
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 51040 -820 0 0 {name=M7_33
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 50230 -430 2 0 {name=R1_33
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 50310 -430 2 0 {name=R2_33
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 50540 -430 2 0 {name=R3_33
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 50730 -430 2 0 {name=R4_33
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 50820 -430 2 0 {name=R5_33
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 51100 -430 2 0 {name=R6_33
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 51190 -430 2 0 {name=R7_33
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 50740 -1380 0 0 {name=lp_ctrl_p_33__33 lab=ctrl_p[33]}
C {devices/lab_pin.sym} 50790 -1380 0 0 {name=lp_ctrl_n_33__33 lab=ctrl_n[33]}
C {devices/lab_pin.sym} 50390 -570 0 0 {name=lp_Gate_33__33 lab=Gate[33]}
C {devices/lab_pin.sym} 50960 -580 0 0 {name=lp_Source_33__33 lab=Source[33]}
C {sg13g2_pr/sg13_lv_pmos.sym} 51880 -820 0 1 {name=M1_34
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 51670 -820 0 0 {name=M2_34
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 51980 -820 0 0 {name=M3_34
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 52380 -820 0 1 {name=M4_34
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 52170 -820 0 0 {name=M5_34
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 52750 -820 0 1 {name=M6_34
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 52540 -820 0 0 {name=M7_34
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 51730 -430 2 0 {name=R1_34
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 51810 -430 2 0 {name=R2_34
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 52040 -430 2 0 {name=R3_34
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 52230 -430 2 0 {name=R4_34
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 52320 -430 2 0 {name=R5_34
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 52600 -430 2 0 {name=R6_34
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 52690 -430 2 0 {name=R7_34
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 52240 -1380 0 0 {name=lp_ctrl_p_34__34 lab=ctrl_p[34]}
C {devices/lab_pin.sym} 52290 -1380 0 0 {name=lp_ctrl_n_34__34 lab=ctrl_n[34]}
C {devices/lab_pin.sym} 51890 -570 0 0 {name=lp_Gate_34__34 lab=Gate[34]}
C {devices/lab_pin.sym} 52460 -580 0 0 {name=lp_Source_34__34 lab=Source[34]}
C {sg13g2_pr/sg13_lv_pmos.sym} 53380 -820 0 1 {name=M1_35
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 53170 -820 0 0 {name=M2_35
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 53480 -820 0 0 {name=M3_35
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 53880 -820 0 1 {name=M4_35
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 53670 -820 0 0 {name=M5_35
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 54250 -820 0 1 {name=M6_35
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 54040 -820 0 0 {name=M7_35
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 53230 -430 2 0 {name=R1_35
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 53310 -430 2 0 {name=R2_35
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 53540 -430 2 0 {name=R3_35
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 53730 -430 2 0 {name=R4_35
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 53820 -430 2 0 {name=R5_35
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 54100 -430 2 0 {name=R6_35
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 54190 -430 2 0 {name=R7_35
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 53740 -1380 0 0 {name=lp_ctrl_p_35__35 lab=ctrl_p[35]}
C {devices/lab_pin.sym} 53790 -1380 0 0 {name=lp_ctrl_n_35__35 lab=ctrl_n[35]}
C {devices/lab_pin.sym} 53390 -570 0 0 {name=lp_Gate_35__35 lab=Gate[35]}
C {devices/lab_pin.sym} 53960 -580 0 0 {name=lp_Source_35__35 lab=Source[35]}
C {sg13g2_pr/sg13_lv_pmos.sym} 54880 -820 0 1 {name=M1_36
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 54670 -820 0 0 {name=M2_36
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 54980 -820 0 0 {name=M3_36
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 55380 -820 0 1 {name=M4_36
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 55170 -820 0 0 {name=M5_36
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 55750 -820 0 1 {name=M6_36
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 55540 -820 0 0 {name=M7_36
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 54730 -430 2 0 {name=R1_36
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 54810 -430 2 0 {name=R2_36
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 55040 -430 2 0 {name=R3_36
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 55230 -430 2 0 {name=R4_36
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 55320 -430 2 0 {name=R5_36
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 55600 -430 2 0 {name=R6_36
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 55690 -430 2 0 {name=R7_36
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 55240 -1380 0 0 {name=lp_ctrl_p_36__36 lab=ctrl_p[36]}
C {devices/lab_pin.sym} 55290 -1380 0 0 {name=lp_ctrl_n_36__36 lab=ctrl_n[36]}
C {devices/lab_pin.sym} 54890 -570 0 0 {name=lp_Gate_36__36 lab=Gate[36]}
C {devices/lab_pin.sym} 55460 -580 0 0 {name=lp_Source_36__36 lab=Source[36]}
C {sg13g2_pr/sg13_lv_pmos.sym} 56380 -820 0 1 {name=M1_37
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 56170 -820 0 0 {name=M2_37
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 56480 -820 0 0 {name=M3_37
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 56880 -820 0 1 {name=M4_37
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 56670 -820 0 0 {name=M5_37
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 57250 -820 0 1 {name=M6_37
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 57040 -820 0 0 {name=M7_37
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 56230 -430 2 0 {name=R1_37
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 56310 -430 2 0 {name=R2_37
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 56540 -430 2 0 {name=R3_37
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 56730 -430 2 0 {name=R4_37
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 56820 -430 2 0 {name=R5_37
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 57100 -430 2 0 {name=R6_37
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 57190 -430 2 0 {name=R7_37
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 56740 -1380 0 0 {name=lp_ctrl_p_37__37 lab=ctrl_p[37]}
C {devices/lab_pin.sym} 56790 -1380 0 0 {name=lp_ctrl_n_37__37 lab=ctrl_n[37]}
C {devices/lab_pin.sym} 56390 -570 0 0 {name=lp_Gate_37__37 lab=Gate[37]}
C {devices/lab_pin.sym} 56960 -580 0 0 {name=lp_Source_37__37 lab=Source[37]}
C {sg13g2_pr/sg13_lv_pmos.sym} 57880 -820 0 1 {name=M1_38
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 57670 -820 0 0 {name=M2_38
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 57980 -820 0 0 {name=M3_38
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 58380 -820 0 1 {name=M4_38
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 58170 -820 0 0 {name=M5_38
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 58750 -820 0 1 {name=M6_38
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 58540 -820 0 0 {name=M7_38
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 57730 -430 2 0 {name=R1_38
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 57810 -430 2 0 {name=R2_38
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 58040 -430 2 0 {name=R3_38
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 58230 -430 2 0 {name=R4_38
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 58320 -430 2 0 {name=R5_38
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 58600 -430 2 0 {name=R6_38
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 58690 -430 2 0 {name=R7_38
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 58240 -1380 0 0 {name=lp_ctrl_p_38__38 lab=ctrl_p[38]}
C {devices/lab_pin.sym} 58290 -1380 0 0 {name=lp_ctrl_n_38__38 lab=ctrl_n[38]}
C {devices/lab_pin.sym} 57890 -570 0 0 {name=lp_Gate_38__38 lab=Gate[38]}
C {devices/lab_pin.sym} 58460 -580 0 0 {name=lp_Source_38__38 lab=Source[38]}
C {sg13g2_pr/sg13_lv_pmos.sym} 59380 -820 0 1 {name=M1_39
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 59170 -820 0 0 {name=M2_39
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 59480 -820 0 0 {name=M3_39
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 59880 -820 0 1 {name=M4_39
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 59670 -820 0 0 {name=M5_39
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 60250 -820 0 1 {name=M6_39
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 60040 -820 0 0 {name=M7_39
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 59230 -430 2 0 {name=R1_39
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 59310 -430 2 0 {name=R2_39
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 59540 -430 2 0 {name=R3_39
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 59730 -430 2 0 {name=R4_39
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 59820 -430 2 0 {name=R5_39
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 60100 -430 2 0 {name=R6_39
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 60190 -430 2 0 {name=R7_39
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 59740 -1380 0 0 {name=lp_ctrl_p_39__39 lab=ctrl_p[39]}
C {devices/lab_pin.sym} 59790 -1380 0 0 {name=lp_ctrl_n_39__39 lab=ctrl_n[39]}
C {devices/lab_pin.sym} 59390 -570 0 0 {name=lp_Gate_39__39 lab=Gate[39]}
C {devices/lab_pin.sym} 59960 -580 0 0 {name=lp_Source_39__39 lab=Source[39]}
C {sg13g2_pr/sg13_lv_pmos.sym} 60880 -820 0 1 {name=M1_40
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 60670 -820 0 0 {name=M2_40
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 60980 -820 0 0 {name=M3_40
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 61380 -820 0 1 {name=M4_40
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 61170 -820 0 0 {name=M5_40
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 61750 -820 0 1 {name=M6_40
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 61540 -820 0 0 {name=M7_40
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 60730 -430 2 0 {name=R1_40
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 60810 -430 2 0 {name=R2_40
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 61040 -430 2 0 {name=R3_40
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 61230 -430 2 0 {name=R4_40
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 61320 -430 2 0 {name=R5_40
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 61600 -430 2 0 {name=R6_40
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 61690 -430 2 0 {name=R7_40
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 61240 -1380 0 0 {name=lp_ctrl_p_40__40 lab=ctrl_p[40]}
C {devices/lab_pin.sym} 61290 -1380 0 0 {name=lp_ctrl_n_40__40 lab=ctrl_n[40]}
C {devices/lab_pin.sym} 60890 -570 0 0 {name=lp_Gate_40__40 lab=Gate[40]}
C {devices/lab_pin.sym} 61460 -580 0 0 {name=lp_Source_40__40 lab=Source[40]}
C {sg13g2_pr/sg13_lv_pmos.sym} 62380 -820 0 1 {name=M1_41
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 62170 -820 0 0 {name=M2_41
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 62480 -820 0 0 {name=M3_41
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 62880 -820 0 1 {name=M4_41
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 62670 -820 0 0 {name=M5_41
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 63250 -820 0 1 {name=M6_41
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 63040 -820 0 0 {name=M7_41
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 62230 -430 2 0 {name=R1_41
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 62310 -430 2 0 {name=R2_41
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 62540 -430 2 0 {name=R3_41
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 62730 -430 2 0 {name=R4_41
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 62820 -430 2 0 {name=R5_41
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 63100 -430 2 0 {name=R6_41
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 63190 -430 2 0 {name=R7_41
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 62740 -1380 0 0 {name=lp_ctrl_p_41__41 lab=ctrl_p[41]}
C {devices/lab_pin.sym} 62790 -1380 0 0 {name=lp_ctrl_n_41__41 lab=ctrl_n[41]}
C {devices/lab_pin.sym} 62390 -570 0 0 {name=lp_Gate_41__41 lab=Gate[41]}
C {devices/lab_pin.sym} 62960 -580 0 0 {name=lp_Source_41__41 lab=Source[41]}
C {sg13g2_pr/sg13_lv_pmos.sym} 63880 -820 0 1 {name=M1_42
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 63670 -820 0 0 {name=M2_42
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 63980 -820 0 0 {name=M3_42
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 64380 -820 0 1 {name=M4_42
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 64170 -820 0 0 {name=M5_42
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 64750 -820 0 1 {name=M6_42
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 64540 -820 0 0 {name=M7_42
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 63730 -430 2 0 {name=R1_42
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 63810 -430 2 0 {name=R2_42
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 64040 -430 2 0 {name=R3_42
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 64230 -430 2 0 {name=R4_42
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 64320 -430 2 0 {name=R5_42
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 64600 -430 2 0 {name=R6_42
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 64690 -430 2 0 {name=R7_42
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 64240 -1380 0 0 {name=lp_ctrl_p_42__42 lab=ctrl_p[42]}
C {devices/lab_pin.sym} 64290 -1380 0 0 {name=lp_ctrl_n_42__42 lab=ctrl_n[42]}
C {devices/lab_pin.sym} 63890 -570 0 0 {name=lp_Gate_42__42 lab=Gate[42]}
C {devices/lab_pin.sym} 64460 -580 0 0 {name=lp_Source_42__42 lab=Source[42]}
C {sg13g2_pr/sg13_lv_pmos.sym} 65380 -820 0 1 {name=M1_43
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 65170 -820 0 0 {name=M2_43
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 65480 -820 0 0 {name=M3_43
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 65880 -820 0 1 {name=M4_43
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 65670 -820 0 0 {name=M5_43
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 66250 -820 0 1 {name=M6_43
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 66040 -820 0 0 {name=M7_43
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 65230 -430 2 0 {name=R1_43
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 65310 -430 2 0 {name=R2_43
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 65540 -430 2 0 {name=R3_43
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 65730 -430 2 0 {name=R4_43
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 65820 -430 2 0 {name=R5_43
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 66100 -430 2 0 {name=R6_43
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 66190 -430 2 0 {name=R7_43
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 65740 -1380 0 0 {name=lp_ctrl_p_43__43 lab=ctrl_p[43]}
C {devices/lab_pin.sym} 65790 -1380 0 0 {name=lp_ctrl_n_43__43 lab=ctrl_n[43]}
C {devices/lab_pin.sym} 65390 -570 0 0 {name=lp_Gate_43__43 lab=Gate[43]}
C {devices/lab_pin.sym} 65960 -580 0 0 {name=lp_Source_43__43 lab=Source[43]}
C {sg13g2_pr/sg13_lv_pmos.sym} 66880 -820 0 1 {name=M1_44
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 66670 -820 0 0 {name=M2_44
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 66980 -820 0 0 {name=M3_44
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 67380 -820 0 1 {name=M4_44
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 67170 -820 0 0 {name=M5_44
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 67750 -820 0 1 {name=M6_44
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 67540 -820 0 0 {name=M7_44
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 66730 -430 2 0 {name=R1_44
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 66810 -430 2 0 {name=R2_44
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 67040 -430 2 0 {name=R3_44
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 67230 -430 2 0 {name=R4_44
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 67320 -430 2 0 {name=R5_44
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 67600 -430 2 0 {name=R6_44
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 67690 -430 2 0 {name=R7_44
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 67240 -1380 0 0 {name=lp_ctrl_p_44__44 lab=ctrl_p[44]}
C {devices/lab_pin.sym} 67290 -1380 0 0 {name=lp_ctrl_n_44__44 lab=ctrl_n[44]}
C {devices/lab_pin.sym} 66890 -570 0 0 {name=lp_Gate_44__44 lab=Gate[44]}
C {devices/lab_pin.sym} 67460 -580 0 0 {name=lp_Source_44__44 lab=Source[44]}
C {sg13g2_pr/sg13_lv_pmos.sym} 68380 -820 0 1 {name=M1_45
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 68170 -820 0 0 {name=M2_45
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 68480 -820 0 0 {name=M3_45
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 68880 -820 0 1 {name=M4_45
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 68670 -820 0 0 {name=M5_45
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 69250 -820 0 1 {name=M6_45
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 69040 -820 0 0 {name=M7_45
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 68230 -430 2 0 {name=R1_45
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 68310 -430 2 0 {name=R2_45
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 68540 -430 2 0 {name=R3_45
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 68730 -430 2 0 {name=R4_45
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 68820 -430 2 0 {name=R5_45
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 69100 -430 2 0 {name=R6_45
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 69190 -430 2 0 {name=R7_45
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 68740 -1380 0 0 {name=lp_ctrl_p_45__45 lab=ctrl_p[45]}
C {devices/lab_pin.sym} 68790 -1380 0 0 {name=lp_ctrl_n_45__45 lab=ctrl_n[45]}
C {devices/lab_pin.sym} 68390 -570 0 0 {name=lp_Gate_45__45 lab=Gate[45]}
C {devices/lab_pin.sym} 68960 -580 0 0 {name=lp_Source_45__45 lab=Source[45]}
C {sg13g2_pr/sg13_lv_pmos.sym} 69880 -820 0 1 {name=M1_46
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 69670 -820 0 0 {name=M2_46
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 69980 -820 0 0 {name=M3_46
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 70380 -820 0 1 {name=M4_46
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 70170 -820 0 0 {name=M5_46
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 70750 -820 0 1 {name=M6_46
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 70540 -820 0 0 {name=M7_46
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 69730 -430 2 0 {name=R1_46
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 69810 -430 2 0 {name=R2_46
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 70040 -430 2 0 {name=R3_46
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 70230 -430 2 0 {name=R4_46
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 70320 -430 2 0 {name=R5_46
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 70600 -430 2 0 {name=R6_46
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 70690 -430 2 0 {name=R7_46
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 70240 -1380 0 0 {name=lp_ctrl_p_46__46 lab=ctrl_p[46]}
C {devices/lab_pin.sym} 70290 -1380 0 0 {name=lp_ctrl_n_46__46 lab=ctrl_n[46]}
C {devices/lab_pin.sym} 69890 -570 0 0 {name=lp_Gate_46__46 lab=Gate[46]}
C {devices/lab_pin.sym} 70460 -580 0 0 {name=lp_Source_46__46 lab=Source[46]}
C {sg13g2_pr/sg13_lv_pmos.sym} 71380 -820 0 1 {name=M1_47
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 71170 -820 0 0 {name=M2_47
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 71480 -820 0 0 {name=M3_47
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 71880 -820 0 1 {name=M4_47
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 71670 -820 0 0 {name=M5_47
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 72250 -820 0 1 {name=M6_47
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 72040 -820 0 0 {name=M7_47
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 71230 -430 2 0 {name=R1_47
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 71310 -430 2 0 {name=R2_47
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 71540 -430 2 0 {name=R3_47
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 71730 -430 2 0 {name=R4_47
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 71820 -430 2 0 {name=R5_47
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 72100 -430 2 0 {name=R6_47
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 72190 -430 2 0 {name=R7_47
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 71740 -1380 0 0 {name=lp_ctrl_p_47__47 lab=ctrl_p[47]}
C {devices/lab_pin.sym} 71790 -1380 0 0 {name=lp_ctrl_n_47__47 lab=ctrl_n[47]}
C {devices/lab_pin.sym} 71390 -570 0 0 {name=lp_Gate_47__47 lab=Gate[47]}
C {devices/lab_pin.sym} 71960 -580 0 0 {name=lp_Source_47__47 lab=Source[47]}
C {sg13g2_pr/sg13_lv_pmos.sym} 72880 -820 0 1 {name=M1_48
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 72670 -820 0 0 {name=M2_48
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 72980 -820 0 0 {name=M3_48
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 73380 -820 0 1 {name=M4_48
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 73170 -820 0 0 {name=M5_48
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 73750 -820 0 1 {name=M6_48
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 73540 -820 0 0 {name=M7_48
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 72730 -430 2 0 {name=R1_48
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 72810 -430 2 0 {name=R2_48
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 73040 -430 2 0 {name=R3_48
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 73230 -430 2 0 {name=R4_48
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 73320 -430 2 0 {name=R5_48
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 73600 -430 2 0 {name=R6_48
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 73690 -430 2 0 {name=R7_48
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 73240 -1380 0 0 {name=lp_ctrl_p_48__48 lab=ctrl_p[48]}
C {devices/lab_pin.sym} 73290 -1380 0 0 {name=lp_ctrl_n_48__48 lab=ctrl_n[48]}
C {devices/lab_pin.sym} 72890 -570 0 0 {name=lp_Gate_48__48 lab=Gate[48]}
C {devices/lab_pin.sym} 73460 -580 0 0 {name=lp_Source_48__48 lab=Source[48]}
C {sg13g2_pr/sg13_lv_pmos.sym} 74380 -820 0 1 {name=M1_49
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 74170 -820 0 0 {name=M2_49
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 74480 -820 0 0 {name=M3_49
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 74880 -820 0 1 {name=M4_49
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 74670 -820 0 0 {name=M5_49
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 75250 -820 0 1 {name=M6_49
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 75040 -820 0 0 {name=M7_49
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 74230 -430 2 0 {name=R1_49
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 74310 -430 2 0 {name=R2_49
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 74540 -430 2 0 {name=R3_49
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 74730 -430 2 0 {name=R4_49
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 74820 -430 2 0 {name=R5_49
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 75100 -430 2 0 {name=R6_49
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 75190 -430 2 0 {name=R7_49
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 74740 -1380 0 0 {name=lp_ctrl_p_49__49 lab=ctrl_p[49]}
C {devices/lab_pin.sym} 74790 -1380 0 0 {name=lp_ctrl_n_49__49 lab=ctrl_n[49]}
C {devices/lab_pin.sym} 74390 -570 0 0 {name=lp_Gate_49__49 lab=Gate[49]}
C {devices/lab_pin.sym} 74960 -580 0 0 {name=lp_Source_49__49 lab=Source[49]}
C {sg13g2_pr/sg13_lv_pmos.sym} 75880 -820 0 1 {name=M1_50
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 75670 -820 0 0 {name=M2_50
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 75980 -820 0 0 {name=M3_50
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 76380 -820 0 1 {name=M4_50
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 76170 -820 0 0 {name=M5_50
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 76750 -820 0 1 {name=M6_50
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 76540 -820 0 0 {name=M7_50
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 75730 -430 2 0 {name=R1_50
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 75810 -430 2 0 {name=R2_50
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 76040 -430 2 0 {name=R3_50
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 76230 -430 2 0 {name=R4_50
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 76320 -430 2 0 {name=R5_50
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 76600 -430 2 0 {name=R6_50
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 76690 -430 2 0 {name=R7_50
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 76240 -1380 0 0 {name=lp_ctrl_p_50__50 lab=ctrl_p[50]}
C {devices/lab_pin.sym} 76290 -1380 0 0 {name=lp_ctrl_n_50__50 lab=ctrl_n[50]}
C {devices/lab_pin.sym} 75890 -570 0 0 {name=lp_Gate_50__50 lab=Gate[50]}
C {devices/lab_pin.sym} 76460 -580 0 0 {name=lp_Source_50__50 lab=Source[50]}
C {sg13g2_pr/sg13_lv_pmos.sym} 77380 -820 0 1 {name=M1_51
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 77170 -820 0 0 {name=M2_51
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 77480 -820 0 0 {name=M3_51
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 77880 -820 0 1 {name=M4_51
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 77670 -820 0 0 {name=M5_51
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 78250 -820 0 1 {name=M6_51
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 78040 -820 0 0 {name=M7_51
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 77230 -430 2 0 {name=R1_51
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 77310 -430 2 0 {name=R2_51
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 77540 -430 2 0 {name=R3_51
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 77730 -430 2 0 {name=R4_51
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 77820 -430 2 0 {name=R5_51
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 78100 -430 2 0 {name=R6_51
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 78190 -430 2 0 {name=R7_51
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 77740 -1380 0 0 {name=lp_ctrl_p_51__51 lab=ctrl_p[51]}
C {devices/lab_pin.sym} 77790 -1380 0 0 {name=lp_ctrl_n_51__51 lab=ctrl_n[51]}
C {devices/lab_pin.sym} 77390 -570 0 0 {name=lp_Gate_51__51 lab=Gate[51]}
C {devices/lab_pin.sym} 77960 -580 0 0 {name=lp_Source_51__51 lab=Source[51]}
C {sg13g2_pr/sg13_lv_pmos.sym} 78880 -820 0 1 {name=M1_52
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 78670 -820 0 0 {name=M2_52
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 78980 -820 0 0 {name=M3_52
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 79380 -820 0 1 {name=M4_52
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 79170 -820 0 0 {name=M5_52
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 79750 -820 0 1 {name=M6_52
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 79540 -820 0 0 {name=M7_52
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 78730 -430 2 0 {name=R1_52
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 78810 -430 2 0 {name=R2_52
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 79040 -430 2 0 {name=R3_52
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 79230 -430 2 0 {name=R4_52
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 79320 -430 2 0 {name=R5_52
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 79600 -430 2 0 {name=R6_52
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 79690 -430 2 0 {name=R7_52
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 79240 -1380 0 0 {name=lp_ctrl_p_52__52 lab=ctrl_p[52]}
C {devices/lab_pin.sym} 79290 -1380 0 0 {name=lp_ctrl_n_52__52 lab=ctrl_n[52]}
C {devices/lab_pin.sym} 78890 -570 0 0 {name=lp_Gate_52__52 lab=Gate[52]}
C {devices/lab_pin.sym} 79460 -580 0 0 {name=lp_Source_52__52 lab=Source[52]}
C {sg13g2_pr/sg13_lv_pmos.sym} 80380 -820 0 1 {name=M1_53
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 80170 -820 0 0 {name=M2_53
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 80480 -820 0 0 {name=M3_53
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 80880 -820 0 1 {name=M4_53
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 80670 -820 0 0 {name=M5_53
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 81250 -820 0 1 {name=M6_53
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 81040 -820 0 0 {name=M7_53
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 80230 -430 2 0 {name=R1_53
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 80310 -430 2 0 {name=R2_53
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 80540 -430 2 0 {name=R3_53
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 80730 -430 2 0 {name=R4_53
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 80820 -430 2 0 {name=R5_53
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 81100 -430 2 0 {name=R6_53
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 81190 -430 2 0 {name=R7_53
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 80740 -1380 0 0 {name=lp_ctrl_p_53__53 lab=ctrl_p[53]}
C {devices/lab_pin.sym} 80790 -1380 0 0 {name=lp_ctrl_n_53__53 lab=ctrl_n[53]}
C {devices/lab_pin.sym} 80390 -570 0 0 {name=lp_Gate_53__53 lab=Gate[53]}
C {devices/lab_pin.sym} 80960 -580 0 0 {name=lp_Source_53__53 lab=Source[53]}
C {sg13g2_pr/sg13_lv_pmos.sym} 81880 -820 0 1 {name=M1_54
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 81670 -820 0 0 {name=M2_54
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 81980 -820 0 0 {name=M3_54
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 82380 -820 0 1 {name=M4_54
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 82170 -820 0 0 {name=M5_54
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 82750 -820 0 1 {name=M6_54
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 82540 -820 0 0 {name=M7_54
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 81730 -430 2 0 {name=R1_54
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 81810 -430 2 0 {name=R2_54
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 82040 -430 2 0 {name=R3_54
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 82230 -430 2 0 {name=R4_54
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 82320 -430 2 0 {name=R5_54
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 82600 -430 2 0 {name=R6_54
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 82690 -430 2 0 {name=R7_54
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 82240 -1380 0 0 {name=lp_ctrl_p_54__54 lab=ctrl_p[54]}
C {devices/lab_pin.sym} 82290 -1380 0 0 {name=lp_ctrl_n_54__54 lab=ctrl_n[54]}
C {devices/lab_pin.sym} 81890 -570 0 0 {name=lp_Gate_54__54 lab=Gate[54]}
C {devices/lab_pin.sym} 82460 -580 0 0 {name=lp_Source_54__54 lab=Source[54]}
C {sg13g2_pr/sg13_lv_pmos.sym} 83380 -820 0 1 {name=M1_55
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 83170 -820 0 0 {name=M2_55
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 83480 -820 0 0 {name=M3_55
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 83880 -820 0 1 {name=M4_55
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 83670 -820 0 0 {name=M5_55
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 84250 -820 0 1 {name=M6_55
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 84040 -820 0 0 {name=M7_55
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 83230 -430 2 0 {name=R1_55
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 83310 -430 2 0 {name=R2_55
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 83540 -430 2 0 {name=R3_55
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 83730 -430 2 0 {name=R4_55
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 83820 -430 2 0 {name=R5_55
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 84100 -430 2 0 {name=R6_55
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 84190 -430 2 0 {name=R7_55
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 83740 -1380 0 0 {name=lp_ctrl_p_55__55 lab=ctrl_p[55]}
C {devices/lab_pin.sym} 83790 -1380 0 0 {name=lp_ctrl_n_55__55 lab=ctrl_n[55]}
C {devices/lab_pin.sym} 83390 -570 0 0 {name=lp_Gate_55__55 lab=Gate[55]}
C {devices/lab_pin.sym} 83960 -580 0 0 {name=lp_Source_55__55 lab=Source[55]}
C {sg13g2_pr/sg13_lv_pmos.sym} 84880 -820 0 1 {name=M1_56
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 84670 -820 0 0 {name=M2_56
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 84980 -820 0 0 {name=M3_56
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 85380 -820 0 1 {name=M4_56
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 85170 -820 0 0 {name=M5_56
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 85750 -820 0 1 {name=M6_56
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 85540 -820 0 0 {name=M7_56
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 84730 -430 2 0 {name=R1_56
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 84810 -430 2 0 {name=R2_56
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 85040 -430 2 0 {name=R3_56
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 85230 -430 2 0 {name=R4_56
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 85320 -430 2 0 {name=R5_56
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 85600 -430 2 0 {name=R6_56
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 85690 -430 2 0 {name=R7_56
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 85240 -1380 0 0 {name=lp_ctrl_p_56__56 lab=ctrl_p[56]}
C {devices/lab_pin.sym} 85290 -1380 0 0 {name=lp_ctrl_n_56__56 lab=ctrl_n[56]}
C {devices/lab_pin.sym} 84890 -570 0 0 {name=lp_Gate_56__56 lab=Gate[56]}
C {devices/lab_pin.sym} 85460 -580 0 0 {name=lp_Source_56__56 lab=Source[56]}
C {sg13g2_pr/sg13_lv_pmos.sym} 86380 -820 0 1 {name=M1_57
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 86170 -820 0 0 {name=M2_57
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 86480 -820 0 0 {name=M3_57
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 86880 -820 0 1 {name=M4_57
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 86670 -820 0 0 {name=M5_57
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 87250 -820 0 1 {name=M6_57
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 87040 -820 0 0 {name=M7_57
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 86230 -430 2 0 {name=R1_57
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 86310 -430 2 0 {name=R2_57
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 86540 -430 2 0 {name=R3_57
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 86730 -430 2 0 {name=R4_57
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 86820 -430 2 0 {name=R5_57
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 87100 -430 2 0 {name=R6_57
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 87190 -430 2 0 {name=R7_57
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 86740 -1380 0 0 {name=lp_ctrl_p_57__57 lab=ctrl_p[57]}
C {devices/lab_pin.sym} 86790 -1380 0 0 {name=lp_ctrl_n_57__57 lab=ctrl_n[57]}
C {devices/lab_pin.sym} 86390 -570 0 0 {name=lp_Gate_57__57 lab=Gate[57]}
C {devices/lab_pin.sym} 86960 -580 0 0 {name=lp_Source_57__57 lab=Source[57]}
C {sg13g2_pr/sg13_lv_pmos.sym} 87880 -820 0 1 {name=M1_58
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 87670 -820 0 0 {name=M2_58
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 87980 -820 0 0 {name=M3_58
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 88380 -820 0 1 {name=M4_58
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 88170 -820 0 0 {name=M5_58
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 88750 -820 0 1 {name=M6_58
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 88540 -820 0 0 {name=M7_58
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 87730 -430 2 0 {name=R1_58
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 87810 -430 2 0 {name=R2_58
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 88040 -430 2 0 {name=R3_58
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 88230 -430 2 0 {name=R4_58
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 88320 -430 2 0 {name=R5_58
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 88600 -430 2 0 {name=R6_58
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 88690 -430 2 0 {name=R7_58
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 88240 -1380 0 0 {name=lp_ctrl_p_58__58 lab=ctrl_p[58]}
C {devices/lab_pin.sym} 88290 -1380 0 0 {name=lp_ctrl_n_58__58 lab=ctrl_n[58]}
C {devices/lab_pin.sym} 87890 -570 0 0 {name=lp_Gate_58__58 lab=Gate[58]}
C {devices/lab_pin.sym} 88460 -580 0 0 {name=lp_Source_58__58 lab=Source[58]}
C {sg13g2_pr/sg13_lv_pmos.sym} 89380 -820 0 1 {name=M1_59
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 89170 -820 0 0 {name=M2_59
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 89480 -820 0 0 {name=M3_59
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 89880 -820 0 1 {name=M4_59
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 89670 -820 0 0 {name=M5_59
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 90250 -820 0 1 {name=M6_59
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 90040 -820 0 0 {name=M7_59
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 89230 -430 2 0 {name=R1_59
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 89310 -430 2 0 {name=R2_59
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 89540 -430 2 0 {name=R3_59
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 89730 -430 2 0 {name=R4_59
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 89820 -430 2 0 {name=R5_59
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 90100 -430 2 0 {name=R6_59
model=ptap1
spiceprefix=X
w=2.0e-6
}
C {sg13g2_pr/ntap1.sym} 90190 -430 2 0 {name=R7_59
model=ntap1
spiceprefix=X
w=2.0e-6
}
C {devices/lab_pin.sym} 89740 -1380 0 0 {name=lp_ctrl_p_59__59 lab=ctrl_p[59]}
C {devices/lab_pin.sym} 89790 -1380 0 0 {name=lp_ctrl_n_59__59 lab=ctrl_n[59]}
C {devices/lab_pin.sym} 89390 -570 0 0 {name=lp_Gate_59__59 lab=Gate[59]}
C {devices/lab_pin.sym} 89960 -580 0 0 {name=lp_Source_59__59 lab=Source[59]}
C {sg13g2_pr/sg13_lv_pmos.sym} 90880 -820 0 1 {name=M1_60
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 90670 -820 0 0 {name=M2_60
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 90980 -820 0 0 {name=M3_60
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 91380 -820 0 1 {name=M4_60
l=0.13u
w=0.30u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 91170 -820 0 0 {name=M5_60
l=0.13u
w=0.15u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 91750 -820 0 1 {name=M6_60
l=0.13u
w=\{m2_w}
C {sg13g2_pr/sg13_lv_nmos.sym} 91540 -820 0 0 {name=M7_60
l=0.13u
w=\{m1_w}
C {sg13g2_pr/ptap1.sym} 90730 -430 2 0 {name=R1_60
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6}
C {sg13g2_pr/ntap1.sym} 90810 -430 2 0 {name=R2_60
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 91040 -430 2 0 {name=R3_60
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 91230 -430 2 0 {name=R4_60
model=ptap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ntap1.sym} 91320 -430 2 0 {name=R5_60
model=ntap1
spiceprefix=X
l=0.78e-6
w=0.78e-6
}
C {sg13g2_pr/ptap1.sym} 91600 -430 2 0 {name=R6_60
model=ptap1
