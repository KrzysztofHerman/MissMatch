v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 100 -830 270 -830 {lab=Drain[0]}
N 270 -830 270 -740 {lab=Drain[0]}
N 190 -740 270 -740 {lab=Drain[0]}
N 100 -830 100 -740 {lab=Drain[0]}
N 190 -740 190 -670 {lab=Drain[0]}
N 100 -740 190 -740 {lab=Drain[0]}
N 370 -670 560 -670 {lab=Drain[0]}
N 370 -670 370 -510 {lab=Drain[0]}
N 470 -830 470 -740 {lab=Drain[0]}
N 560 -740 640 -740 {lab=Drain[0]}
N 640 -830 640 -740 {lab=Drain[0]}
N 560 -740 560 -670 {lab=Drain[0]}
N 470 -740 560 -740 {lab=Drain[0]}
N 100 -970 100 -890 {lab=Dsense}
N 190 -970 270 -970 {lab=Dsense}
N 270 -970 270 -890 {lab=Dsense}
N 470 -970 470 -890 {lab=Dforce}
N 560 -970 640 -970 {lab=Dforce}
N 640 -970 640 -890 {lab=Dforce}
N 190 -1090 190 -970 {lab=Dsense}
N 100 -970 190 -970 {lab=Dsense}
N 560 -1060 1460 -1060 {lab=Dforce}
N 560 -1060 560 -970 {lab=Dforce}
N 470 -970 560 -970 {lab=Dforce}
N 680 -860 700 -860 {lab=ctrl_p[0]}
N 700 -1130 700 -860 {lab=ctrl_p[0]}
N 290 -1230 290 -1130 {lab=ctrl_p[0]}
N 290 -1130 700 -1130 {lab=ctrl_p[0]}
N 20 -1130 20 -860 {lab=ctrl_p[0]}
N 20 -860 60 -860 {lab=ctrl_p[0]}
N 470 -860 520 -860 {lab=net1_0}
N 230 -860 270 -860 {lab=net1_0}
N 100 -860 140 -860 {lab=net2_0}
N 750 -1000 1650 -1000 {lab=Vss}
N 590 -860 640 -860 {lab=net2_0}
N 370 -950 370 -930 {lab=net1_0}
N 370 -930 520 -930 {lab=net1_0}
N 230 -930 230 -860 {lab=net1_0}
N 520 -930 520 -860 {lab=net1_0}
N 370 -1030 370 -1010 {lab=1.2V}
N 140 -860 140 -810 {lab=net2_0}
N 140 -810 370 -810 {lab=net2_0}
N 370 -810 370 -780 {lab=net2_0}
N 370 -720 370 -700 {lab=Vss}
N 370 -700 750 -700 {lab=Vss}
N 750 -1000 750 -700 {lab=Vss}
N 190 -670 370 -670 {lab=Drain[0]}
N 370 -810 590 -810 {lab=net2_0}
N 590 -860 590 -810 {lab=net2_0}
N 20 -1130 290 -1130 {lab=ctrl_p[0]}
N 330 -860 430 -860 {lab=ctrl_n[0]}
N 230 -930 370 -930 {lab=net1_0}
N 330 -1230 330 -860 {lab=ctrl_n[0]}
N 310 -860 330 -860 {lab=ctrl_n[0]}
N 1000 -830 1170 -830 {lab=Drain[1]}
N 1170 -830 1170 -740 {lab=Drain[1]}
N 1090 -740 1170 -740 {lab=Drain[1]}
N 1000 -830 1000 -740 {lab=Drain[1]}
N 1090 -740 1090 -670 {lab=Drain[1]}
N 1000 -740 1090 -740 {lab=Drain[1]}
N 1270 -670 1460 -670 {lab=Drain[1]}
N 1270 -670 1270 -510 {lab=Drain[1]}
N 1370 -830 1370 -740 {lab=Drain[1]}
N 1460 -740 1540 -740 {lab=Drain[1]}
N 1540 -830 1540 -740 {lab=Drain[1]}
N 1460 -740 1460 -670 {lab=Drain[1]}
N 1370 -740 1460 -740 {lab=Drain[1]}
N 1000 -970 1000 -890 {lab=Dsense}
N 1090 -970 1170 -970 {lab=Dsense}
N 1170 -970 1170 -890 {lab=Dsense}
N 1370 -970 1370 -890 {lab=Dforce}
N 1460 -970 1540 -970 {lab=Dforce}
N 1540 -970 1540 -890 {lab=Dforce}
N 1090 -1090 1990 -1090 {lab=Dsense}
N 1090 -1090 1090 -970 {lab=Dsense}
N 1000 -970 1090 -970 {lab=Dsense}
N 1460 -1060 2360 -1060 {lab=Dforce}
N 1460 -1060 1460 -970 {lab=Dforce}
N 1370 -970 1460 -970 {lab=Dforce}
N 1580 -860 1600 -860 {lab=ctrl_p[1]}
N 1600 -1130 1600 -860 {lab=ctrl_p[1]}
N 1190 -1230 1190 -1130 {lab=ctrl_p[1]}
N 1190 -1130 1600 -1130 {lab=ctrl_p[1]}
N 920 -1130 920 -860 {lab=ctrl_p[1]}
N 920 -860 960 -860 {lab=ctrl_p[1]}
N 1370 -860 1420 -860 {lab=net1_1}
N 1130 -860 1170 -860 {lab=net1_1}
N 1000 -860 1040 -860 {lab=net2_1}
N 1650 -1000 2550 -1000 {lab=Vss}
N 1490 -860 1540 -860 {lab=net2_1}
N 1270 -950 1270 -930 {lab=net1_1}
N 1270 -930 1420 -930 {lab=net1_1}
N 1130 -930 1130 -860 {lab=net1_1}
N 1420 -930 1420 -860 {lab=net1_1}
N 1270 -1030 1270 -1010 {lab=1.2V}
N 1040 -860 1040 -810 {lab=net2_1}
N 1040 -810 1270 -810 {lab=net2_1}
N 1270 -810 1270 -780 {lab=net2_1}
N 1270 -720 1270 -700 {lab=Vss}
N 1270 -700 1650 -700 {lab=Vss}
N 1650 -1000 1650 -700 {lab=Vss}
N 1090 -670 1270 -670 {lab=Drain[1]}
N 1270 -810 1490 -810 {lab=net2_1}
N 1490 -860 1490 -810 {lab=net2_1}
N 920 -1130 1190 -1130 {lab=ctrl_p[1]}
N 1230 -860 1330 -860 {lab=ctrl_n[1]}
N 1130 -930 1270 -930 {lab=net1_1}
N 1270 -1030 2170 -1030 {lab=1.2V}
N 1230 -1230 1230 -860 {lab=ctrl_n[1]}
N 1210 -860 1230 -860 {lab=ctrl_n[1]}
N 1900 -830 2070 -830 {lab=Drain[2]}
N 2070 -830 2070 -740 {lab=Drain[2]}
N 1990 -740 2070 -740 {lab=Drain[2]}
N 1900 -830 1900 -740 {lab=Drain[2]}
N 1990 -740 1990 -670 {lab=Drain[2]}
N 1900 -740 1990 -740 {lab=Drain[2]}
N 2170 -670 2360 -670 {lab=Drain[2]}
N 2170 -670 2170 -510 {lab=Drain[2]}
N 2270 -830 2270 -740 {lab=Drain[2]}
N 2360 -740 2440 -740 {lab=Drain[2]}
N 2440 -830 2440 -740 {lab=Drain[2]}
N 2360 -740 2360 -670 {lab=Drain[2]}
N 2270 -740 2360 -740 {lab=Drain[2]}
N 1900 -970 1900 -890 {lab=Dsense}
N 1990 -970 2070 -970 {lab=Dsense}
N 2070 -970 2070 -890 {lab=Dsense}
N 2270 -970 2270 -890 {lab=Dforce}
N 2360 -970 2440 -970 {lab=Dforce}
N 2440 -970 2440 -890 {lab=Dforce}
N 1990 -1090 2890 -1090 {lab=Dsense}
N 1990 -1090 1990 -970 {lab=Dsense}
N 1900 -970 1990 -970 {lab=Dsense}
N 2360 -1060 3260 -1060 {lab=Dforce}
N 2360 -1060 2360 -970 {lab=Dforce}
N 2270 -970 2360 -970 {lab=Dforce}
N 2480 -860 2500 -860 {lab=ctrl_p[2]}
N 2500 -1130 2500 -860 {lab=ctrl_p[2]}
N 2090 -1230 2090 -1130 {lab=ctrl_p[2]}
N 2090 -1130 2500 -1130 {lab=ctrl_p[2]}
N 1820 -1130 1820 -860 {lab=ctrl_p[2]}
N 1820 -860 1860 -860 {lab=ctrl_p[2]}
N 2270 -860 2320 -860 {lab=net1_2}
N 2030 -860 2070 -860 {lab=net1_2}
N 1900 -860 1940 -860 {lab=net2_2}
N 2550 -1000 3450 -1000 {lab=Vss}
N 2390 -860 2440 -860 {lab=net2_2}
N 2170 -950 2170 -930 {lab=net1_2}
N 2170 -930 2320 -930 {lab=net1_2}
N 2030 -930 2030 -860 {lab=net1_2}
N 2320 -930 2320 -860 {lab=net1_2}
N 2170 -1030 2170 -1010 {lab=1.2V}
N 1940 -860 1940 -810 {lab=net2_2}
N 1940 -810 2170 -810 {lab=net2_2}
N 2170 -810 2170 -780 {lab=net2_2}
N 2170 -720 2170 -700 {lab=Vss}
N 2170 -700 2550 -700 {lab=Vss}
N 2550 -1000 2550 -700 {lab=Vss}
N 1990 -670 2170 -670 {lab=Drain[2]}
N 2170 -810 2390 -810 {lab=net2_2}
N 2390 -860 2390 -810 {lab=net2_2}
N 1820 -1130 2090 -1130 {lab=ctrl_p[2]}
N 2130 -860 2230 -860 {lab=ctrl_n[2]}
N 2030 -930 2170 -930 {lab=net1_2}
N 2170 -1030 3070 -1030 {lab=1.2V}
N 2130 -1230 2130 -860 {lab=ctrl_n[2]}
N 2110 -860 2130 -860 {lab=ctrl_n[2]}
N 2800 -830 2970 -830 {lab=Drain[3]}
N 2970 -830 2970 -740 {lab=Drain[3]}
N 2890 -740 2970 -740 {lab=Drain[3]}
N 2800 -830 2800 -740 {lab=Drain[3]}
N 2890 -740 2890 -670 {lab=Drain[3]}
N 2800 -740 2890 -740 {lab=Drain[3]}
N 3070 -670 3260 -670 {lab=Drain[3]}
N 3070 -670 3070 -510 {lab=Drain[3]}
N 3170 -830 3170 -740 {lab=Drain[3]}
N 3260 -740 3340 -740 {lab=Drain[3]}
N 3340 -830 3340 -740 {lab=Drain[3]}
N 3260 -740 3260 -670 {lab=Drain[3]}
N 3170 -740 3260 -740 {lab=Drain[3]}
N 2800 -970 2800 -890 {lab=Dsense}
N 2890 -970 2970 -970 {lab=Dsense}
N 2970 -970 2970 -890 {lab=Dsense}
N 3170 -970 3170 -890 {lab=Dforce}
N 3260 -970 3340 -970 {lab=Dforce}
N 3340 -970 3340 -890 {lab=Dforce}
N 2890 -1090 3790 -1090 {lab=Dsense}
N 2890 -1090 2890 -970 {lab=Dsense}
N 2800 -970 2890 -970 {lab=Dsense}
N 3260 -1060 4160 -1060 {lab=Dforce}
N 3260 -1060 3260 -970 {lab=Dforce}
N 3170 -970 3260 -970 {lab=Dforce}
N 3380 -860 3400 -860 {lab=ctrl_p[3]}
N 3400 -1130 3400 -860 {lab=ctrl_p[3]}
N 2990 -1230 2990 -1130 {lab=ctrl_p[3]}
N 2990 -1130 3400 -1130 {lab=ctrl_p[3]}
N 2720 -1130 2720 -860 {lab=ctrl_p[3]}
N 2720 -860 2760 -860 {lab=ctrl_p[3]}
N 3170 -860 3220 -860 {lab=net1_3}
N 2930 -860 2970 -860 {lab=net1_3}
N 2800 -860 2840 -860 {lab=net2_3}
N 3450 -1000 4350 -1000 {lab=Vss}
N 3290 -860 3340 -860 {lab=net2_3}
N 3070 -950 3070 -930 {lab=net1_3}
N 3070 -930 3220 -930 {lab=net1_3}
N 2930 -930 2930 -860 {lab=net1_3}
N 3220 -930 3220 -860 {lab=net1_3}
N 3070 -1030 3070 -1010 {lab=1.2V}
N 2840 -860 2840 -810 {lab=net2_3}
N 2840 -810 3070 -810 {lab=net2_3}
N 3070 -810 3070 -780 {lab=net2_3}
N 3070 -720 3070 -700 {lab=Vss}
N 3070 -700 3450 -700 {lab=Vss}
N 3450 -1000 3450 -700 {lab=Vss}
N 2890 -670 3070 -670 {lab=Drain[3]}
N 3070 -810 3290 -810 {lab=net2_3}
N 3290 -860 3290 -810 {lab=net2_3}
N 2720 -1130 2990 -1130 {lab=ctrl_p[3]}
N 3030 -860 3130 -860 {lab=ctrl_n[3]}
N 2930 -930 3070 -930 {lab=net1_3}
N 3070 -1030 3970 -1030 {lab=1.2V}
N 3030 -1230 3030 -860 {lab=ctrl_n[3]}
N 3010 -860 3030 -860 {lab=ctrl_n[3]}
N 3700 -830 3870 -830 {lab=Drain[4]}
N 3870 -830 3870 -740 {lab=Drain[4]}
N 3790 -740 3870 -740 {lab=Drain[4]}
N 3700 -830 3700 -740 {lab=Drain[4]}
N 3790 -740 3790 -670 {lab=Drain[4]}
N 3700 -740 3790 -740 {lab=Drain[4]}
N 3970 -670 4160 -670 {lab=Drain[4]}
N 3970 -670 3970 -510 {lab=Drain[4]}
N 4070 -830 4070 -740 {lab=Drain[4]}
N 4160 -740 4240 -740 {lab=Drain[4]}
N 4240 -830 4240 -740 {lab=Drain[4]}
N 4160 -740 4160 -670 {lab=Drain[4]}
N 4070 -740 4160 -740 {lab=Drain[4]}
N 3700 -970 3700 -890 {lab=Dsense}
N 3790 -970 3870 -970 {lab=Dsense}
N 3870 -970 3870 -890 {lab=Dsense}
N 4070 -970 4070 -890 {lab=Dforce}
N 4160 -970 4240 -970 {lab=Dforce}
N 4240 -970 4240 -890 {lab=Dforce}
N 3790 -1090 4690 -1090 {lab=Dsense}
N 3790 -1090 3790 -970 {lab=Dsense}
N 3700 -970 3790 -970 {lab=Dsense}
N 4160 -1060 5060 -1060 {lab=Dforce}
N 4160 -1060 4160 -970 {lab=Dforce}
N 4070 -970 4160 -970 {lab=Dforce}
N 4280 -860 4300 -860 {lab=ctrl_p[4]}
N 4300 -1130 4300 -860 {lab=ctrl_p[4]}
N 3890 -1230 3890 -1130 {lab=ctrl_p[4]}
N 3890 -1130 4300 -1130 {lab=ctrl_p[4]}
N 3620 -1130 3620 -860 {lab=ctrl_p[4]}
N 3620 -860 3660 -860 {lab=ctrl_p[4]}
N 4070 -860 4120 -860 {lab=net1_4}
N 3830 -860 3870 -860 {lab=net1_4}
N 3700 -860 3740 -860 {lab=net2_4}
N 4350 -1000 5250 -1000 {lab=Vss}
N 4190 -860 4240 -860 {lab=net2_4}
N 3970 -950 3970 -930 {lab=net1_4}
N 3970 -930 4120 -930 {lab=net1_4}
N 3830 -930 3830 -860 {lab=net1_4}
N 4120 -930 4120 -860 {lab=net1_4}
N 3970 -1030 3970 -1010 {lab=1.2V}
N 3740 -860 3740 -810 {lab=net2_4}
N 3740 -810 3970 -810 {lab=net2_4}
N 3970 -810 3970 -780 {lab=net2_4}
N 3970 -720 3970 -700 {lab=Vss}
N 3970 -700 4350 -700 {lab=Vss}
N 4350 -1000 4350 -700 {lab=Vss}
N 3790 -670 3970 -670 {lab=Drain[4]}
N 3970 -810 4190 -810 {lab=net2_4}
N 4190 -860 4190 -810 {lab=net2_4}
N 3620 -1130 3890 -1130 {lab=ctrl_p[4]}
N 3930 -860 4030 -860 {lab=ctrl_n[4]}
N 3830 -930 3970 -930 {lab=net1_4}
N 3970 -1030 4870 -1030 {lab=1.2V}
N 3930 -1230 3930 -860 {lab=ctrl_n[4]}
N 3910 -860 3930 -860 {lab=ctrl_n[4]}
N 4600 -830 4770 -830 {lab=Drain[5]}
N 4770 -830 4770 -740 {lab=Drain[5]}
N 4690 -740 4770 -740 {lab=Drain[5]}
N 4600 -830 4600 -740 {lab=Drain[5]}
N 4690 -740 4690 -670 {lab=Drain[5]}
N 4600 -740 4690 -740 {lab=Drain[5]}
N 4870 -670 5060 -670 {lab=Drain[5]}
N 4870 -670 4870 -510 {lab=Drain[5]}
N 4970 -830 4970 -740 {lab=Drain[5]}
N 5060 -740 5140 -740 {lab=Drain[5]}
N 5140 -830 5140 -740 {lab=Drain[5]}
N 5060 -740 5060 -670 {lab=Drain[5]}
N 4970 -740 5060 -740 {lab=Drain[5]}
N 4600 -970 4600 -890 {lab=Dsense}
N 4690 -970 4770 -970 {lab=Dsense}
N 4770 -970 4770 -890 {lab=Dsense}
N 4970 -970 4970 -890 {lab=Dforce}
N 5060 -970 5140 -970 {lab=Dforce}
N 5140 -970 5140 -890 {lab=Dforce}
N 4690 -1090 5590 -1090 {lab=Dsense}
N 4690 -1090 4690 -970 {lab=Dsense}
N 4600 -970 4690 -970 {lab=Dsense}
N 5060 -1060 5960 -1060 {lab=Dforce}
N 5060 -1060 5060 -970 {lab=Dforce}
N 4970 -970 5060 -970 {lab=Dforce}
N 5180 -860 5200 -860 {lab=ctrl_p[5]}
N 5200 -1130 5200 -860 {lab=ctrl_p[5]}
N 4790 -1230 4790 -1130 {lab=ctrl_p[5]}
N 4790 -1130 5200 -1130 {lab=ctrl_p[5]}
N 4520 -1130 4520 -860 {lab=ctrl_p[5]}
N 4520 -860 4560 -860 {lab=ctrl_p[5]}
N 4970 -860 5020 -860 {lab=net1_5}
N 4730 -860 4770 -860 {lab=net1_5}
N 4600 -860 4640 -860 {lab=net2_5}
N 5250 -1000 6150 -1000 {lab=Vss}
N 5090 -860 5140 -860 {lab=net2_5}
N 4870 -950 4870 -930 {lab=net1_5}
N 4870 -930 5020 -930 {lab=net1_5}
N 4730 -930 4730 -860 {lab=net1_5}
N 5020 -930 5020 -860 {lab=net1_5}
N 4870 -1030 4870 -1010 {lab=1.2V}
N 4640 -860 4640 -810 {lab=net2_5}
N 4640 -810 4870 -810 {lab=net2_5}
N 4870 -810 4870 -780 {lab=net2_5}
N 4870 -720 4870 -700 {lab=Vss}
N 4870 -700 5250 -700 {lab=Vss}
N 5250 -1000 5250 -700 {lab=Vss}
N 4690 -670 4870 -670 {lab=Drain[5]}
N 4870 -810 5090 -810 {lab=net2_5}
N 5090 -860 5090 -810 {lab=net2_5}
N 4520 -1130 4790 -1130 {lab=ctrl_p[5]}
N 4830 -860 4930 -860 {lab=ctrl_n[5]}
N 4730 -930 4870 -930 {lab=net1_5}
N 4870 -1030 5770 -1030 {lab=1.2V}
N 4830 -1230 4830 -860 {lab=ctrl_n[5]}
N 4810 -860 4830 -860 {lab=ctrl_n[5]}
N 5500 -830 5670 -830 {lab=Drain[6]}
N 5670 -830 5670 -740 {lab=Drain[6]}
N 5590 -740 5670 -740 {lab=Drain[6]}
N 5500 -830 5500 -740 {lab=Drain[6]}
N 5590 -740 5590 -670 {lab=Drain[6]}
N 5500 -740 5590 -740 {lab=Drain[6]}
N 5770 -670 5960 -670 {lab=Drain[6]}
N 5770 -670 5770 -510 {lab=Drain[6]}
N 5870 -830 5870 -740 {lab=Drain[6]}
N 5960 -740 6040 -740 {lab=Drain[6]}
N 6040 -830 6040 -740 {lab=Drain[6]}
N 5960 -740 5960 -670 {lab=Drain[6]}
N 5870 -740 5960 -740 {lab=Drain[6]}
N 5500 -970 5500 -890 {lab=Dsense}
N 5590 -970 5670 -970 {lab=Dsense}
N 5670 -970 5670 -890 {lab=Dsense}
N 5870 -970 5870 -890 {lab=Dforce}
N 5960 -970 6040 -970 {lab=Dforce}
N 6040 -970 6040 -890 {lab=Dforce}
N 5590 -1090 6490 -1090 {lab=Dsense}
N 5590 -1090 5590 -970 {lab=Dsense}
N 5500 -970 5590 -970 {lab=Dsense}
N 5960 -1060 6860 -1060 {lab=Dforce}
N 5960 -1060 5960 -970 {lab=Dforce}
N 5870 -970 5960 -970 {lab=Dforce}
N 6080 -860 6100 -860 {lab=ctrl_p[6]}
N 6100 -1130 6100 -860 {lab=ctrl_p[6]}
N 5690 -1230 5690 -1130 {lab=ctrl_p[6]}
N 5690 -1130 6100 -1130 {lab=ctrl_p[6]}
N 5420 -1130 5420 -860 {lab=ctrl_p[6]}
N 5420 -860 5460 -860 {lab=ctrl_p[6]}
N 5870 -860 5920 -860 {lab=net1_6}
N 5630 -860 5670 -860 {lab=net1_6}
N 5500 -860 5540 -860 {lab=net2_6}
N 6150 -1000 7050 -1000 {lab=Vss}
N 5990 -860 6040 -860 {lab=net2_6}
N 5770 -950 5770 -930 {lab=net1_6}
N 5770 -930 5920 -930 {lab=net1_6}
N 5630 -930 5630 -860 {lab=net1_6}
N 5920 -930 5920 -860 {lab=net1_6}
N 5770 -1030 5770 -1010 {lab=1.2V}
N 5540 -860 5540 -810 {lab=net2_6}
N 5540 -810 5770 -810 {lab=net2_6}
N 5770 -810 5770 -780 {lab=net2_6}
N 5770 -720 5770 -700 {lab=Vss}
N 5770 -700 6150 -700 {lab=Vss}
N 6150 -1000 6150 -700 {lab=Vss}
N 5590 -670 5770 -670 {lab=Drain[6]}
N 5770 -810 5990 -810 {lab=net2_6}
N 5990 -860 5990 -810 {lab=net2_6}
N 5420 -1130 5690 -1130 {lab=ctrl_p[6]}
N 5730 -860 5830 -860 {lab=ctrl_n[6]}
N 5630 -930 5770 -930 {lab=net1_6}
N 5770 -1030 6670 -1030 {lab=1.2V}
N 5730 -1230 5730 -860 {lab=ctrl_n[6]}
N 5710 -860 5730 -860 {lab=ctrl_n[6]}
N 6400 -830 6570 -830 {lab=Drain[7]}
N 6570 -830 6570 -740 {lab=Drain[7]}
N 6490 -740 6570 -740 {lab=Drain[7]}
N 6400 -830 6400 -740 {lab=Drain[7]}
N 6490 -740 6490 -670 {lab=Drain[7]}
N 6400 -740 6490 -740 {lab=Drain[7]}
N 6670 -670 6860 -670 {lab=Drain[7]}
N 6670 -670 6670 -510 {lab=Drain[7]}
N 6770 -830 6770 -740 {lab=Drain[7]}
N 6860 -740 6940 -740 {lab=Drain[7]}
N 6940 -830 6940 -740 {lab=Drain[7]}
N 6860 -740 6860 -670 {lab=Drain[7]}
N 6770 -740 6860 -740 {lab=Drain[7]}
N 6400 -970 6400 -890 {lab=Dsense}
N 6490 -970 6570 -970 {lab=Dsense}
N 6570 -970 6570 -890 {lab=Dsense}
N 6770 -970 6770 -890 {lab=Dforce}
N 6860 -970 6940 -970 {lab=Dforce}
N 6940 -970 6940 -890 {lab=Dforce}
N 6490 -1090 7390 -1090 {lab=Dsense}
N 6490 -1090 6490 -970 {lab=Dsense}
N 6400 -970 6490 -970 {lab=Dsense}
N 6860 -1060 7760 -1060 {lab=Dforce}
N 6860 -1060 6860 -970 {lab=Dforce}
N 6770 -970 6860 -970 {lab=Dforce}
N 6980 -860 7000 -860 {lab=ctrl_p[7]}
N 7000 -1130 7000 -860 {lab=ctrl_p[7]}
N 6590 -1230 6590 -1130 {lab=ctrl_p[7]}
N 6590 -1130 7000 -1130 {lab=ctrl_p[7]}
N 6320 -1130 6320 -860 {lab=ctrl_p[7]}
N 6320 -860 6360 -860 {lab=ctrl_p[7]}
N 6770 -860 6820 -860 {lab=net1_7}
N 6530 -860 6570 -860 {lab=net1_7}
N 6400 -860 6440 -860 {lab=net2_7}
N 7050 -1000 7950 -1000 {lab=Vss}
N 6890 -860 6940 -860 {lab=net2_7}
N 6670 -950 6670 -930 {lab=net1_7}
N 6670 -930 6820 -930 {lab=net1_7}
N 6530 -930 6530 -860 {lab=net1_7}
N 6820 -930 6820 -860 {lab=net1_7}
N 6670 -1030 6670 -1010 {lab=1.2V}
N 6440 -860 6440 -810 {lab=net2_7}
N 6440 -810 6670 -810 {lab=net2_7}
N 6670 -810 6670 -780 {lab=net2_7}
N 6670 -720 6670 -700 {lab=Vss}
N 6670 -700 7050 -700 {lab=Vss}
N 7050 -1000 7050 -700 {lab=Vss}
N 6490 -670 6670 -670 {lab=Drain[7]}
N 6670 -810 6890 -810 {lab=net2_7}
N 6890 -860 6890 -810 {lab=net2_7}
N 6320 -1130 6590 -1130 {lab=ctrl_p[7]}
N 6630 -860 6730 -860 {lab=ctrl_n[7]}
N 6530 -930 6670 -930 {lab=net1_7}
N 6670 -1030 7570 -1030 {lab=1.2V}
N 6630 -1230 6630 -860 {lab=ctrl_n[7]}
N 6610 -860 6630 -860 {lab=ctrl_n[7]}
N 7300 -830 7470 -830 {lab=Drain[8]}
N 7470 -830 7470 -740 {lab=Drain[8]}
N 7390 -740 7470 -740 {lab=Drain[8]}
N 7300 -830 7300 -740 {lab=Drain[8]}
N 7390 -740 7390 -670 {lab=Drain[8]}
N 7300 -740 7390 -740 {lab=Drain[8]}
N 7570 -670 7760 -670 {lab=Drain[8]}
N 7570 -670 7570 -510 {lab=Drain[8]}
N 7670 -830 7670 -740 {lab=Drain[8]}
N 7760 -740 7840 -740 {lab=Drain[8]}
N 7840 -830 7840 -740 {lab=Drain[8]}
N 7760 -740 7760 -670 {lab=Drain[8]}
N 7670 -740 7760 -740 {lab=Drain[8]}
N 7300 -970 7300 -890 {lab=Dsense}
N 7390 -970 7470 -970 {lab=Dsense}
N 7470 -970 7470 -890 {lab=Dsense}
N 7670 -970 7670 -890 {lab=Dforce}
N 7760 -970 7840 -970 {lab=Dforce}
N 7840 -970 7840 -890 {lab=Dforce}
N 7390 -1090 8290 -1090 {lab=Dsense}
N 7390 -1090 7390 -970 {lab=Dsense}
N 7300 -970 7390 -970 {lab=Dsense}
N 7760 -1060 8660 -1060 {lab=Dforce}
N 7760 -1060 7760 -970 {lab=Dforce}
N 7670 -970 7760 -970 {lab=Dforce}
N 7880 -860 7900 -860 {lab=ctrl_p[8]}
N 7900 -1130 7900 -860 {lab=ctrl_p[8]}
N 7490 -1230 7490 -1130 {lab=ctrl_p[8]}
N 7490 -1130 7900 -1130 {lab=ctrl_p[8]}
N 7220 -1130 7220 -860 {lab=ctrl_p[8]}
N 7220 -860 7260 -860 {lab=ctrl_p[8]}
N 7670 -860 7720 -860 {lab=net1_8}
N 7430 -860 7470 -860 {lab=net1_8}
N 7300 -860 7340 -860 {lab=net2_8}
N 7950 -1000 8850 -1000 {lab=Vss}
N 7790 -860 7840 -860 {lab=net2_8}
N 7570 -950 7570 -930 {lab=net1_8}
N 7570 -930 7720 -930 {lab=net1_8}
N 7430 -930 7430 -860 {lab=net1_8}
N 7720 -930 7720 -860 {lab=net1_8}
N 7570 -1030 7570 -1010 {lab=1.2V}
N 7340 -860 7340 -810 {lab=net2_8}
N 7340 -810 7570 -810 {lab=net2_8}
N 7570 -810 7570 -780 {lab=net2_8}
N 7570 -720 7570 -700 {lab=Vss}
N 7570 -700 7950 -700 {lab=Vss}
N 7950 -1000 7950 -700 {lab=Vss}
N 7390 -670 7570 -670 {lab=Drain[8]}
N 7570 -810 7790 -810 {lab=net2_8}
N 7790 -860 7790 -810 {lab=net2_8}
N 7220 -1130 7490 -1130 {lab=ctrl_p[8]}
N 7530 -860 7630 -860 {lab=ctrl_n[8]}
N 7430 -930 7570 -930 {lab=net1_8}
N 7570 -1030 8470 -1030 {lab=1.2V}
N 7530 -1230 7530 -860 {lab=ctrl_n[8]}
N 7510 -860 7530 -860 {lab=ctrl_n[8]}
N 8200 -830 8370 -830 {lab=Drain[9]}
N 8370 -830 8370 -740 {lab=Drain[9]}
N 8290 -740 8370 -740 {lab=Drain[9]}
N 8200 -830 8200 -740 {lab=Drain[9]}
N 8290 -740 8290 -670 {lab=Drain[9]}
N 8200 -740 8290 -740 {lab=Drain[9]}
N 8470 -670 8660 -670 {lab=Drain[9]}
N 8470 -670 8470 -510 {lab=Drain[9]}
N 8570 -830 8570 -740 {lab=Drain[9]}
N 8660 -740 8740 -740 {lab=Drain[9]}
N 8740 -830 8740 -740 {lab=Drain[9]}
N 8660 -740 8660 -670 {lab=Drain[9]}
N 8570 -740 8660 -740 {lab=Drain[9]}
N 8200 -970 8200 -890 {lab=Dsense}
N 8290 -970 8370 -970 {lab=Dsense}
N 8370 -970 8370 -890 {lab=Dsense}
N 8570 -970 8570 -890 {lab=Dforce}
N 8660 -970 8740 -970 {lab=Dforce}
N 8740 -970 8740 -890 {lab=Dforce}
N 8290 -1090 9190 -1090 {lab=Dsense}
N 8290 -1090 8290 -970 {lab=Dsense}
N 8200 -970 8290 -970 {lab=Dsense}
N 8660 -1060 9560 -1060 {lab=Dforce}
N 8660 -1060 8660 -970 {lab=Dforce}
N 8570 -970 8660 -970 {lab=Dforce}
N 8780 -860 8800 -860 {lab=ctrl_p[9]}
N 8800 -1130 8800 -860 {lab=ctrl_p[9]}
N 8390 -1230 8390 -1130 {lab=ctrl_p[9]}
N 8390 -1130 8800 -1130 {lab=ctrl_p[9]}
N 8120 -1130 8120 -860 {lab=ctrl_p[9]}
N 8120 -860 8160 -860 {lab=ctrl_p[9]}
N 8570 -860 8620 -860 {lab=net1_9}
N 8330 -860 8370 -860 {lab=net1_9}
N 8200 -860 8240 -860 {lab=net2_9}
N 8850 -1000 9750 -1000 {lab=Vss}
N 8690 -860 8740 -860 {lab=net2_9}
N 8470 -950 8470 -930 {lab=net1_9}
N 8470 -930 8620 -930 {lab=net1_9}
N 8330 -930 8330 -860 {lab=net1_9}
N 8620 -930 8620 -860 {lab=net1_9}
N 8470 -1030 8470 -1010 {lab=1.2V}
N 8240 -860 8240 -810 {lab=net2_9}
N 8240 -810 8470 -810 {lab=net2_9}
N 8470 -810 8470 -780 {lab=net2_9}
N 8470 -720 8470 -700 {lab=Vss}
N 8470 -700 8850 -700 {lab=Vss}
N 8850 -1000 8850 -700 {lab=Vss}
N 8290 -670 8470 -670 {lab=Drain[9]}
N 8470 -810 8690 -810 {lab=net2_9}
N 8690 -860 8690 -810 {lab=net2_9}
N 8120 -1130 8390 -1130 {lab=ctrl_p[9]}
N 8430 -860 8530 -860 {lab=ctrl_n[9]}
N 8330 -930 8470 -930 {lab=net1_9}
N 8470 -1030 9370 -1030 {lab=1.2V}
N 8430 -1230 8430 -860 {lab=ctrl_n[9]}
N 8410 -860 8430 -860 {lab=ctrl_n[9]}
N 9100 -830 9270 -830 {lab=Drain[10]}
N 9270 -830 9270 -740 {lab=Drain[10]}
N 9190 -740 9270 -740 {lab=Drain[10]}
N 9100 -830 9100 -740 {lab=Drain[10]}
N 9190 -740 9190 -670 {lab=Drain[10]}
N 9100 -740 9190 -740 {lab=Drain[10]}
N 9370 -670 9560 -670 {lab=Drain[10]}
N 9370 -670 9370 -510 {lab=Drain[10]}
N 9470 -830 9470 -740 {lab=Drain[10]}
N 9560 -740 9640 -740 {lab=Drain[10]}
N 9640 -830 9640 -740 {lab=Drain[10]}
N 9560 -740 9560 -670 {lab=Drain[10]}
N 9470 -740 9560 -740 {lab=Drain[10]}
N 9100 -970 9100 -890 {lab=Dsense}
N 9190 -970 9270 -970 {lab=Dsense}
N 9270 -970 9270 -890 {lab=Dsense}
N 9470 -970 9470 -890 {lab=Dforce}
N 9560 -970 9640 -970 {lab=Dforce}
N 9640 -970 9640 -890 {lab=Dforce}
N 9190 -1090 10090 -1090 {lab=Dsense}
N 9190 -1090 9190 -970 {lab=Dsense}
N 9100 -970 9190 -970 {lab=Dsense}
N 9560 -1060 10460 -1060 {lab=Dforce}
N 9560 -1060 9560 -970 {lab=Dforce}
N 9470 -970 9560 -970 {lab=Dforce}
N 9680 -860 9700 -860 {lab=ctrl_p[10]}
N 9700 -1130 9700 -860 {lab=ctrl_p[10]}
N 9290 -1230 9290 -1130 {lab=ctrl_p[10]}
N 9290 -1130 9700 -1130 {lab=ctrl_p[10]}
N 9020 -1130 9020 -860 {lab=ctrl_p[10]}
N 9020 -860 9060 -860 {lab=ctrl_p[10]}
N 9470 -860 9520 -860 {lab=net1_10}
N 9230 -860 9270 -860 {lab=net1_10}
N 9100 -860 9140 -860 {lab=net2_10}
N 9750 -1000 10650 -1000 {lab=Vss}
N 9590 -860 9640 -860 {lab=net2_10}
N 9370 -950 9370 -930 {lab=net1_10}
N 9370 -930 9520 -930 {lab=net1_10}
N 9230 -930 9230 -860 {lab=net1_10}
N 9520 -930 9520 -860 {lab=net1_10}
N 9370 -1030 9370 -1010 {lab=1.2V}
N 9140 -860 9140 -810 {lab=net2_10}
N 9140 -810 9370 -810 {lab=net2_10}
N 9370 -810 9370 -780 {lab=net2_10}
N 9370 -720 9370 -700 {lab=Vss}
N 9370 -700 9750 -700 {lab=Vss}
N 9750 -1000 9750 -700 {lab=Vss}
N 9190 -670 9370 -670 {lab=Drain[10]}
N 9370 -810 9590 -810 {lab=net2_10}
N 9590 -860 9590 -810 {lab=net2_10}
N 9020 -1130 9290 -1130 {lab=ctrl_p[10]}
N 9330 -860 9430 -860 {lab=ctrl_n[10]}
N 9230 -930 9370 -930 {lab=net1_10}
N 9370 -1030 10270 -1030 {lab=1.2V}
N 9330 -1230 9330 -860 {lab=ctrl_n[10]}
N 9310 -860 9330 -860 {lab=ctrl_n[10]}
N 10000 -830 10170 -830 {lab=Drain[11]}
N 10170 -830 10170 -740 {lab=Drain[11]}
N 10090 -740 10170 -740 {lab=Drain[11]}
N 10000 -830 10000 -740 {lab=Drain[11]}
N 10090 -740 10090 -670 {lab=Drain[11]}
N 10000 -740 10090 -740 {lab=Drain[11]}
N 10270 -670 10460 -670 {lab=Drain[11]}
N 10270 -670 10270 -510 {lab=Drain[11]}
N 10370 -830 10370 -740 {lab=Drain[11]}
N 10460 -740 10540 -740 {lab=Drain[11]}
N 10540 -830 10540 -740 {lab=Drain[11]}
N 10460 -740 10460 -670 {lab=Drain[11]}
N 10370 -740 10460 -740 {lab=Drain[11]}
N 10000 -970 10000 -890 {lab=Dsense}
N 10090 -970 10170 -970 {lab=Dsense}
N 10170 -970 10170 -890 {lab=Dsense}
N 10370 -970 10370 -890 {lab=Dforce}
N 10460 -970 10540 -970 {lab=Dforce}
N 10540 -970 10540 -890 {lab=Dforce}
N 10090 -1090 10990 -1090 {lab=Dsense}
N 10090 -1090 10090 -970 {lab=Dsense}
N 10000 -970 10090 -970 {lab=Dsense}
N 10460 -1060 11360 -1060 {lab=Dforce}
N 10460 -1060 10460 -970 {lab=Dforce}
N 10370 -970 10460 -970 {lab=Dforce}
N 10580 -860 10600 -860 {lab=ctrl_p[11]}
N 10600 -1130 10600 -860 {lab=ctrl_p[11]}
N 10190 -1230 10190 -1130 {lab=ctrl_p[11]}
N 10190 -1130 10600 -1130 {lab=ctrl_p[11]}
N 9920 -1130 9920 -860 {lab=ctrl_p[11]}
N 9920 -860 9960 -860 {lab=ctrl_p[11]}
N 10370 -860 10420 -860 {lab=net1_11}
N 10130 -860 10170 -860 {lab=net1_11}
N 10000 -860 10040 -860 {lab=net2_11}
N 10650 -1000 11550 -1000 {lab=Vss}
N 10490 -860 10540 -860 {lab=net2_11}
N 10270 -950 10270 -930 {lab=net1_11}
N 10270 -930 10420 -930 {lab=net1_11}
N 10130 -930 10130 -860 {lab=net1_11}
N 10420 -930 10420 -860 {lab=net1_11}
N 10270 -1030 10270 -1010 {lab=1.2V}
N 10040 -860 10040 -810 {lab=net2_11}
N 10040 -810 10270 -810 {lab=net2_11}
N 10270 -810 10270 -780 {lab=net2_11}
N 10270 -720 10270 -700 {lab=Vss}
N 10270 -700 10650 -700 {lab=Vss}
N 10650 -1000 10650 -700 {lab=Vss}
N 10090 -670 10270 -670 {lab=Drain[11]}
N 10270 -810 10490 -810 {lab=net2_11}
N 10490 -860 10490 -810 {lab=net2_11}
N 9920 -1130 10190 -1130 {lab=ctrl_p[11]}
N 10230 -860 10330 -860 {lab=ctrl_n[11]}
N 10130 -930 10270 -930 {lab=net1_11}
N 10270 -1030 11170 -1030 {lab=1.2V}
N 10230 -1230 10230 -860 {lab=ctrl_n[11]}
N 10210 -860 10230 -860 {lab=ctrl_n[11]}
N 10900 -830 11070 -830 {lab=Drain[12]}
N 11070 -830 11070 -740 {lab=Drain[12]}
N 10990 -740 11070 -740 {lab=Drain[12]}
N 10900 -830 10900 -740 {lab=Drain[12]}
N 10990 -740 10990 -670 {lab=Drain[12]}
N 10900 -740 10990 -740 {lab=Drain[12]}
N 11170 -670 11360 -670 {lab=Drain[12]}
N 11170 -670 11170 -510 {lab=Drain[12]}
N 11270 -830 11270 -740 {lab=Drain[12]}
N 11360 -740 11440 -740 {lab=Drain[12]}
N 11440 -830 11440 -740 {lab=Drain[12]}
N 11360 -740 11360 -670 {lab=Drain[12]}
N 11270 -740 11360 -740 {lab=Drain[12]}
N 10900 -970 10900 -890 {lab=Dsense}
N 10990 -970 11070 -970 {lab=Dsense}
N 11070 -970 11070 -890 {lab=Dsense}
N 11270 -970 11270 -890 {lab=Dforce}
N 11360 -970 11440 -970 {lab=Dforce}
N 11440 -970 11440 -890 {lab=Dforce}
N 10990 -1090 11890 -1090 {lab=Dsense}
N 10990 -1090 10990 -970 {lab=Dsense}
N 10900 -970 10990 -970 {lab=Dsense}
N 11360 -1060 12260 -1060 {lab=Dforce}
N 11360 -1060 11360 -970 {lab=Dforce}
N 11270 -970 11360 -970 {lab=Dforce}
N 11480 -860 11500 -860 {lab=ctrl_p[12]}
N 11500 -1130 11500 -860 {lab=ctrl_p[12]}
N 11090 -1230 11090 -1130 {lab=ctrl_p[12]}
N 11090 -1130 11500 -1130 {lab=ctrl_p[12]}
N 10820 -1130 10820 -860 {lab=ctrl_p[12]}
N 10820 -860 10860 -860 {lab=ctrl_p[12]}
N 11270 -860 11320 -860 {lab=net1_12}
N 11030 -860 11070 -860 {lab=net1_12}
N 10900 -860 10940 -860 {lab=net2_12}
N 11550 -1000 12450 -1000 {lab=Vss}
N 11390 -860 11440 -860 {lab=net2_12}
N 11170 -950 11170 -930 {lab=net1_12}
N 11170 -930 11320 -930 {lab=net1_12}
N 11030 -930 11030 -860 {lab=net1_12}
N 11320 -930 11320 -860 {lab=net1_12}
N 11170 -1030 11170 -1010 {lab=1.2V}
N 10940 -860 10940 -810 {lab=net2_12}
N 10940 -810 11170 -810 {lab=net2_12}
N 11170 -810 11170 -780 {lab=net2_12}
N 11170 -720 11170 -700 {lab=Vss}
N 11170 -700 11550 -700 {lab=Vss}
N 11550 -1000 11550 -700 {lab=Vss}
N 10990 -670 11170 -670 {lab=Drain[12]}
N 11170 -810 11390 -810 {lab=net2_12}
N 11390 -860 11390 -810 {lab=net2_12}
N 10820 -1130 11090 -1130 {lab=ctrl_p[12]}
N 11130 -860 11230 -860 {lab=ctrl_n[12]}
N 11030 -930 11170 -930 {lab=net1_12}
N 11170 -1030 12070 -1030 {lab=1.2V}
N 11130 -1230 11130 -860 {lab=ctrl_n[12]}
N 11110 -860 11130 -860 {lab=ctrl_n[12]}
N 11800 -830 11970 -830 {lab=Drain[13]}
N 11970 -830 11970 -740 {lab=Drain[13]}
N 11890 -740 11970 -740 {lab=Drain[13]}
N 11800 -830 11800 -740 {lab=Drain[13]}
N 11890 -740 11890 -670 {lab=Drain[13]}
N 11800 -740 11890 -740 {lab=Drain[13]}
N 12070 -670 12260 -670 {lab=Drain[13]}
N 12070 -670 12070 -510 {lab=Drain[13]}
N 12170 -830 12170 -740 {lab=Drain[13]}
N 12260 -740 12340 -740 {lab=Drain[13]}
N 12340 -830 12340 -740 {lab=Drain[13]}
N 12260 -740 12260 -670 {lab=Drain[13]}
N 12170 -740 12260 -740 {lab=Drain[13]}
N 11800 -970 11800 -890 {lab=Dsense}
N 11890 -970 11970 -970 {lab=Dsense}
N 11970 -970 11970 -890 {lab=Dsense}
N 12170 -970 12170 -890 {lab=Dforce}
N 12260 -970 12340 -970 {lab=Dforce}
N 12340 -970 12340 -890 {lab=Dforce}
N 11890 -1090 12790 -1090 {lab=Dsense}
N 11890 -1090 11890 -970 {lab=Dsense}
N 11800 -970 11890 -970 {lab=Dsense}
N 12260 -1060 13160 -1060 {lab=Dforce}
N 12260 -1060 12260 -970 {lab=Dforce}
N 12170 -970 12260 -970 {lab=Dforce}
N 12380 -860 12400 -860 {lab=ctrl_p[13]}
N 12400 -1130 12400 -860 {lab=ctrl_p[13]}
N 11990 -1230 11990 -1130 {lab=ctrl_p[13]}
N 11990 -1130 12400 -1130 {lab=ctrl_p[13]}
N 11720 -1130 11720 -860 {lab=ctrl_p[13]}
N 11720 -860 11760 -860 {lab=ctrl_p[13]}
N 12170 -860 12220 -860 {lab=net1_13}
N 11930 -860 11970 -860 {lab=net1_13}
N 11800 -860 11840 -860 {lab=net2_13}
N 12450 -1000 13350 -1000 {lab=Vss}
N 12290 -860 12340 -860 {lab=net2_13}
N 12070 -950 12070 -930 {lab=net1_13}
N 12070 -930 12220 -930 {lab=net1_13}
N 11930 -930 11930 -860 {lab=net1_13}
N 12220 -930 12220 -860 {lab=net1_13}
N 12070 -1030 12070 -1010 {lab=1.2V}
N 11840 -860 11840 -810 {lab=net2_13}
N 11840 -810 12070 -810 {lab=net2_13}
N 12070 -810 12070 -780 {lab=net2_13}
N 12070 -720 12070 -700 {lab=Vss}
N 12070 -700 12450 -700 {lab=Vss}
N 12450 -1000 12450 -700 {lab=Vss}
N 11890 -670 12070 -670 {lab=Drain[13]}
N 12070 -810 12290 -810 {lab=net2_13}
N 12290 -860 12290 -810 {lab=net2_13}
N 11720 -1130 11990 -1130 {lab=ctrl_p[13]}
N 12030 -860 12130 -860 {lab=ctrl_n[13]}
N 11930 -930 12070 -930 {lab=net1_13}
N 12070 -1030 12970 -1030 {lab=1.2V}
N 12030 -1230 12030 -860 {lab=ctrl_n[13]}
N 12010 -860 12030 -860 {lab=ctrl_n[13]}
N 12700 -830 12870 -830 {lab=Drain[14]}
N 12870 -830 12870 -740 {lab=Drain[14]}
N 12790 -740 12870 -740 {lab=Drain[14]}
N 12700 -830 12700 -740 {lab=Drain[14]}
N 12790 -740 12790 -670 {lab=Drain[14]}
N 12700 -740 12790 -740 {lab=Drain[14]}
N 12970 -670 13160 -670 {lab=Drain[14]}
N 12970 -670 12970 -510 {lab=Drain[14]}
N 13070 -830 13070 -740 {lab=Drain[14]}
N 13160 -740 13240 -740 {lab=Drain[14]}
N 13240 -830 13240 -740 {lab=Drain[14]}
N 13160 -740 13160 -670 {lab=Drain[14]}
N 13070 -740 13160 -740 {lab=Drain[14]}
N 12700 -970 12700 -890 {lab=Dsense}
N 12790 -970 12870 -970 {lab=Dsense}
N 12870 -970 12870 -890 {lab=Dsense}
N 13070 -970 13070 -890 {lab=Dforce}
N 13160 -970 13240 -970 {lab=Dforce}
N 13240 -970 13240 -890 {lab=Dforce}
N 12790 -1090 13690 -1090 {lab=Dsense}
N 12790 -1090 12790 -970 {lab=Dsense}
N 12700 -970 12790 -970 {lab=Dsense}
N 13160 -1060 14060 -1060 {lab=Dforce}
N 13160 -1060 13160 -970 {lab=Dforce}
N 13070 -970 13160 -970 {lab=Dforce}
N 13280 -860 13300 -860 {lab=ctrl_p[14]}
N 13300 -1130 13300 -860 {lab=ctrl_p[14]}
N 12890 -1230 12890 -1130 {lab=ctrl_p[14]}
N 12890 -1130 13300 -1130 {lab=ctrl_p[14]}
N 12620 -1130 12620 -860 {lab=ctrl_p[14]}
N 12620 -860 12660 -860 {lab=ctrl_p[14]}
N 13070 -860 13120 -860 {lab=net1_14}
N 12830 -860 12870 -860 {lab=net1_14}
N 12700 -860 12740 -860 {lab=net2_14}
N 13350 -1000 14250 -1000 {lab=Vss}
N 13190 -860 13240 -860 {lab=net2_14}
N 12970 -950 12970 -930 {lab=net1_14}
N 12970 -930 13120 -930 {lab=net1_14}
N 12830 -930 12830 -860 {lab=net1_14}
N 13120 -930 13120 -860 {lab=net1_14}
N 12970 -1030 12970 -1010 {lab=1.2V}
N 12740 -860 12740 -810 {lab=net2_14}
N 12740 -810 12970 -810 {lab=net2_14}
N 12970 -810 12970 -780 {lab=net2_14}
N 12970 -720 12970 -700 {lab=Vss}
N 12970 -700 13350 -700 {lab=Vss}
N 13350 -1000 13350 -700 {lab=Vss}
N 12790 -670 12970 -670 {lab=Drain[14]}
N 12970 -810 13190 -810 {lab=net2_14}
N 13190 -860 13190 -810 {lab=net2_14}
N 12620 -1130 12890 -1130 {lab=ctrl_p[14]}
N 12930 -860 13030 -860 {lab=ctrl_n[14]}
N 12830 -930 12970 -930 {lab=net1_14}
N 12970 -1030 13870 -1030 {lab=1.2V}
N 12930 -1230 12930 -860 {lab=ctrl_n[14]}
N 12910 -860 12930 -860 {lab=ctrl_n[14]}
N 13600 -830 13770 -830 {lab=Drain[15]}
N 13770 -830 13770 -740 {lab=Drain[15]}
N 13690 -740 13770 -740 {lab=Drain[15]}
N 13600 -830 13600 -740 {lab=Drain[15]}
N 13690 -740 13690 -670 {lab=Drain[15]}
N 13600 -740 13690 -740 {lab=Drain[15]}
N 13870 -670 14060 -670 {lab=Drain[15]}
N 13870 -670 13870 -510 {lab=Drain[15]}
N 13970 -830 13970 -740 {lab=Drain[15]}
N 14060 -740 14140 -740 {lab=Drain[15]}
N 14140 -830 14140 -740 {lab=Drain[15]}
N 14060 -740 14060 -670 {lab=Drain[15]}
N 13970 -740 14060 -740 {lab=Drain[15]}
N 13600 -970 13600 -890 {lab=Dsense}
N 13690 -970 13770 -970 {lab=Dsense}
N 13770 -970 13770 -890 {lab=Dsense}
N 13970 -970 13970 -890 {lab=Dforce}
N 14060 -970 14140 -970 {lab=Dforce}
N 14140 -970 14140 -890 {lab=Dforce}
N 13690 -1090 14590 -1090 {lab=Dsense}
N 13690 -1090 13690 -970 {lab=Dsense}
N 13600 -970 13690 -970 {lab=Dsense}
N 14060 -1060 14960 -1060 {lab=Dforce}
N 14060 -1060 14060 -970 {lab=Dforce}
N 13970 -970 14060 -970 {lab=Dforce}
N 14180 -860 14200 -860 {lab=ctrl_p[15]}
N 14200 -1130 14200 -860 {lab=ctrl_p[15]}
N 13790 -1230 13790 -1130 {lab=ctrl_p[15]}
N 13790 -1130 14200 -1130 {lab=ctrl_p[15]}
N 13520 -1130 13520 -860 {lab=ctrl_p[15]}
N 13520 -860 13560 -860 {lab=ctrl_p[15]}
N 13970 -860 14020 -860 {lab=net1_15}
N 13730 -860 13770 -860 {lab=net1_15}
N 13600 -860 13640 -860 {lab=net2_15}
N 14250 -1000 15150 -1000 {lab=Vss}
N 14090 -860 14140 -860 {lab=net2_15}
N 13870 -950 13870 -930 {lab=net1_15}
N 13870 -930 14020 -930 {lab=net1_15}
N 13730 -930 13730 -860 {lab=net1_15}
N 14020 -930 14020 -860 {lab=net1_15}
N 13870 -1030 13870 -1010 {lab=1.2V}
N 13640 -860 13640 -810 {lab=net2_15}
N 13640 -810 13870 -810 {lab=net2_15}
N 13870 -810 13870 -780 {lab=net2_15}
N 13870 -720 13870 -700 {lab=Vss}
N 13870 -700 14250 -700 {lab=Vss}
N 14250 -1000 14250 -700 {lab=Vss}
N 13690 -670 13870 -670 {lab=Drain[15]}
N 13870 -810 14090 -810 {lab=net2_15}
N 14090 -860 14090 -810 {lab=net2_15}
N 13520 -1130 13790 -1130 {lab=ctrl_p[15]}
N 13830 -860 13930 -860 {lab=ctrl_n[15]}
N 13730 -930 13870 -930 {lab=net1_15}
N 13870 -1030 14770 -1030 {lab=1.2V}
N 13830 -1230 13830 -860 {lab=ctrl_n[15]}
N 13810 -860 13830 -860 {lab=ctrl_n[15]}
N 14500 -830 14670 -830 {lab=Drain[16]}
N 14670 -830 14670 -740 {lab=Drain[16]}
N 14590 -740 14670 -740 {lab=Drain[16]}
N 14500 -830 14500 -740 {lab=Drain[16]}
N 14590 -740 14590 -670 {lab=Drain[16]}
N 14500 -740 14590 -740 {lab=Drain[16]}
N 14770 -670 14960 -670 {lab=Drain[16]}
N 14770 -670 14770 -510 {lab=Drain[16]}
N 14870 -830 14870 -740 {lab=Drain[16]}
N 14960 -740 15040 -740 {lab=Drain[16]}
N 15040 -830 15040 -740 {lab=Drain[16]}
N 14960 -740 14960 -670 {lab=Drain[16]}
N 14870 -740 14960 -740 {lab=Drain[16]}
N 14500 -970 14500 -890 {lab=Dsense}
N 14590 -970 14670 -970 {lab=Dsense}
N 14670 -970 14670 -890 {lab=Dsense}
N 14870 -970 14870 -890 {lab=Dforce}
N 14960 -970 15040 -970 {lab=Dforce}
N 15040 -970 15040 -890 {lab=Dforce}
N 14590 -1090 15490 -1090 {lab=Dsense}
N 14590 -1090 14590 -970 {lab=Dsense}
N 14500 -970 14590 -970 {lab=Dsense}
N 14960 -1060 15860 -1060 {lab=Dforce}
N 14960 -1060 14960 -970 {lab=Dforce}
N 14870 -970 14960 -970 {lab=Dforce}
N 15080 -860 15100 -860 {lab=ctrl_p[16]}
N 15100 -1130 15100 -860 {lab=ctrl_p[16]}
N 14690 -1230 14690 -1130 {lab=ctrl_p[16]}
N 14690 -1130 15100 -1130 {lab=ctrl_p[16]}
N 14420 -1130 14420 -860 {lab=ctrl_p[16]}
N 14420 -860 14460 -860 {lab=ctrl_p[16]}
N 14870 -860 14920 -860 {lab=net1_16}
N 14630 -860 14670 -860 {lab=net1_16}
N 14500 -860 14540 -860 {lab=net2_16}
N 15150 -1000 16050 -1000 {lab=Vss}
N 14990 -860 15040 -860 {lab=net2_16}
N 14770 -950 14770 -930 {lab=net1_16}
N 14770 -930 14920 -930 {lab=net1_16}
N 14630 -930 14630 -860 {lab=net1_16}
N 14920 -930 14920 -860 {lab=net1_16}
N 14770 -1030 14770 -1010 {lab=1.2V}
N 14540 -860 14540 -810 {lab=net2_16}
N 14540 -810 14770 -810 {lab=net2_16}
N 14770 -810 14770 -780 {lab=net2_16}
N 14770 -720 14770 -700 {lab=Vss}
N 14770 -700 15150 -700 {lab=Vss}
N 15150 -1000 15150 -700 {lab=Vss}
N 14590 -670 14770 -670 {lab=Drain[16]}
N 14770 -810 14990 -810 {lab=net2_16}
N 14990 -860 14990 -810 {lab=net2_16}
N 14420 -1130 14690 -1130 {lab=ctrl_p[16]}
N 14730 -860 14830 -860 {lab=ctrl_n[16]}
N 14630 -930 14770 -930 {lab=net1_16}
N 14770 -1030 15670 -1030 {lab=1.2V}
N 14730 -1230 14730 -860 {lab=ctrl_n[16]}
N 14710 -860 14730 -860 {lab=ctrl_n[16]}
N 15400 -830 15570 -830 {lab=Drain[17]}
N 15570 -830 15570 -740 {lab=Drain[17]}
N 15490 -740 15570 -740 {lab=Drain[17]}
N 15400 -830 15400 -740 {lab=Drain[17]}
N 15490 -740 15490 -670 {lab=Drain[17]}
N 15400 -740 15490 -740 {lab=Drain[17]}
N 15670 -670 15860 -670 {lab=Drain[17]}
N 15670 -670 15670 -510 {lab=Drain[17]}
N 15770 -830 15770 -740 {lab=Drain[17]}
N 15860 -740 15940 -740 {lab=Drain[17]}
N 15940 -830 15940 -740 {lab=Drain[17]}
N 15860 -740 15860 -670 {lab=Drain[17]}
N 15770 -740 15860 -740 {lab=Drain[17]}
N 15400 -970 15400 -890 {lab=Dsense}
N 15490 -970 15570 -970 {lab=Dsense}
N 15570 -970 15570 -890 {lab=Dsense}
N 15770 -970 15770 -890 {lab=Dforce}
N 15860 -970 15940 -970 {lab=Dforce}
N 15940 -970 15940 -890 {lab=Dforce}
N 15490 -1090 16390 -1090 {lab=Dsense}
N 15490 -1090 15490 -970 {lab=Dsense}
N 15400 -970 15490 -970 {lab=Dsense}
N 15860 -1060 16760 -1060 {lab=Dforce}
N 15860 -1060 15860 -970 {lab=Dforce}
N 15770 -970 15860 -970 {lab=Dforce}
N 15980 -860 16000 -860 {lab=ctrl_p[17]}
N 16000 -1130 16000 -860 {lab=ctrl_p[17]}
N 15590 -1230 15590 -1130 {lab=ctrl_p[17]}
N 15590 -1130 16000 -1130 {lab=ctrl_p[17]}
N 15320 -1130 15320 -860 {lab=ctrl_p[17]}
N 15320 -860 15360 -860 {lab=ctrl_p[17]}
N 15770 -860 15820 -860 {lab=net1_17}
N 15530 -860 15570 -860 {lab=net1_17}
N 15400 -860 15440 -860 {lab=net2_17}
N 16050 -1000 16950 -1000 {lab=Vss}
N 15890 -860 15940 -860 {lab=net2_17}
N 15670 -950 15670 -930 {lab=net1_17}
N 15670 -930 15820 -930 {lab=net1_17}
N 15530 -930 15530 -860 {lab=net1_17}
N 15820 -930 15820 -860 {lab=net1_17}
N 15670 -1030 15670 -1010 {lab=1.2V}
N 15440 -860 15440 -810 {lab=net2_17}
N 15440 -810 15670 -810 {lab=net2_17}
N 15670 -810 15670 -780 {lab=net2_17}
N 15670 -720 15670 -700 {lab=Vss}
N 15670 -700 16050 -700 {lab=Vss}
N 16050 -1000 16050 -700 {lab=Vss}
N 15490 -670 15670 -670 {lab=Drain[17]}
N 15670 -810 15890 -810 {lab=net2_17}
N 15890 -860 15890 -810 {lab=net2_17}
N 15320 -1130 15590 -1130 {lab=ctrl_p[17]}
N 15630 -860 15730 -860 {lab=ctrl_n[17]}
N 15530 -930 15670 -930 {lab=net1_17}
N 15670 -1030 16570 -1030 {lab=1.2V}
N 15630 -1230 15630 -860 {lab=ctrl_n[17]}
N 15610 -860 15630 -860 {lab=ctrl_n[17]}
N 16300 -830 16470 -830 {lab=Drain[18]}
N 16470 -830 16470 -740 {lab=Drain[18]}
N 16390 -740 16470 -740 {lab=Drain[18]}
N 16300 -830 16300 -740 {lab=Drain[18]}
N 16390 -740 16390 -670 {lab=Drain[18]}
N 16300 -740 16390 -740 {lab=Drain[18]}
N 16570 -670 16760 -670 {lab=Drain[18]}
N 16570 -670 16570 -510 {lab=Drain[18]}
N 16670 -830 16670 -740 {lab=Drain[18]}
N 16760 -740 16840 -740 {lab=Drain[18]}
N 16840 -830 16840 -740 {lab=Drain[18]}
N 16760 -740 16760 -670 {lab=Drain[18]}
N 16670 -740 16760 -740 {lab=Drain[18]}
N 16300 -970 16300 -890 {lab=Dsense}
N 16390 -970 16470 -970 {lab=Dsense}
N 16470 -970 16470 -890 {lab=Dsense}
N 16670 -970 16670 -890 {lab=Dforce}
N 16760 -970 16840 -970 {lab=Dforce}
N 16840 -970 16840 -890 {lab=Dforce}
N 16390 -1090 17290 -1090 {lab=Dsense}
N 16390 -1090 16390 -970 {lab=Dsense}
N 16300 -970 16390 -970 {lab=Dsense}
N 16760 -1060 17660 -1060 {lab=Dforce}
N 16760 -1060 16760 -970 {lab=Dforce}
N 16670 -970 16760 -970 {lab=Dforce}
N 16880 -860 16900 -860 {lab=ctrl_p[18]}
N 16900 -1130 16900 -860 {lab=ctrl_p[18]}
N 16490 -1230 16490 -1130 {lab=ctrl_p[18]}
N 16490 -1130 16900 -1130 {lab=ctrl_p[18]}
N 16220 -1130 16220 -860 {lab=ctrl_p[18]}
N 16220 -860 16260 -860 {lab=ctrl_p[18]}
N 16670 -860 16720 -860 {lab=net1_18}
N 16430 -860 16470 -860 {lab=net1_18}
N 16300 -860 16340 -860 {lab=net2_18}
N 16950 -1000 17850 -1000 {lab=Vss}
N 16790 -860 16840 -860 {lab=net2_18}
N 16570 -950 16570 -930 {lab=net1_18}
N 16570 -930 16720 -930 {lab=net1_18}
N 16430 -930 16430 -860 {lab=net1_18}
N 16720 -930 16720 -860 {lab=net1_18}
N 16570 -1030 16570 -1010 {lab=1.2V}
N 16340 -860 16340 -810 {lab=net2_18}
N 16340 -810 16570 -810 {lab=net2_18}
N 16570 -810 16570 -780 {lab=net2_18}
N 16570 -720 16570 -700 {lab=Vss}
N 16570 -700 16950 -700 {lab=Vss}
N 16950 -1000 16950 -700 {lab=Vss}
N 16390 -670 16570 -670 {lab=Drain[18]}
N 16570 -810 16790 -810 {lab=net2_18}
N 16790 -860 16790 -810 {lab=net2_18}
N 16220 -1130 16490 -1130 {lab=ctrl_p[18]}
N 16530 -860 16630 -860 {lab=ctrl_n[18]}
N 16430 -930 16570 -930 {lab=net1_18}
N 16570 -1030 17470 -1030 {lab=1.2V}
N 16530 -1230 16530 -860 {lab=ctrl_n[18]}
N 16510 -860 16530 -860 {lab=ctrl_n[18]}
N 17200 -830 17370 -830 {lab=Drain[19]}
N 17370 -830 17370 -740 {lab=Drain[19]}
N 17290 -740 17370 -740 {lab=Drain[19]}
N 17200 -830 17200 -740 {lab=Drain[19]}
N 17290 -740 17290 -670 {lab=Drain[19]}
N 17200 -740 17290 -740 {lab=Drain[19]}
N 17470 -670 17660 -670 {lab=Drain[19]}
N 17470 -670 17470 -510 {lab=Drain[19]}
N 17570 -830 17570 -740 {lab=Drain[19]}
N 17660 -740 17740 -740 {lab=Drain[19]}
N 17740 -830 17740 -740 {lab=Drain[19]}
N 17660 -740 17660 -670 {lab=Drain[19]}
N 17570 -740 17660 -740 {lab=Drain[19]}
N 17200 -970 17200 -890 {lab=Dsense}
N 17290 -970 17370 -970 {lab=Dsense}
N 17370 -970 17370 -890 {lab=Dsense}
N 17570 -970 17570 -890 {lab=Dforce}
N 17660 -970 17740 -970 {lab=Dforce}
N 17740 -970 17740 -890 {lab=Dforce}
N 17290 -1090 18190 -1090 {lab=Dsense}
N 17290 -1090 17290 -970 {lab=Dsense}
N 17200 -970 17290 -970 {lab=Dsense}
N 17660 -1060 18560 -1060 {lab=Dforce}
N 17660 -1060 17660 -970 {lab=Dforce}
N 17570 -970 17660 -970 {lab=Dforce}
N 17780 -860 17800 -860 {lab=ctrl_p[19]}
N 17800 -1130 17800 -860 {lab=ctrl_p[19]}
N 17390 -1230 17390 -1130 {lab=ctrl_p[19]}
N 17390 -1130 17800 -1130 {lab=ctrl_p[19]}
N 17120 -1130 17120 -860 {lab=ctrl_p[19]}
N 17120 -860 17160 -860 {lab=ctrl_p[19]}
N 17570 -860 17620 -860 {lab=net1_19}
N 17330 -860 17370 -860 {lab=net1_19}
N 17200 -860 17240 -860 {lab=net2_19}
N 17850 -1000 18750 -1000 {lab=Vss}
N 17690 -860 17740 -860 {lab=net2_19}
N 17470 -950 17470 -930 {lab=net1_19}
N 17470 -930 17620 -930 {lab=net1_19}
N 17330 -930 17330 -860 {lab=net1_19}
N 17620 -930 17620 -860 {lab=net1_19}
N 17470 -1030 17470 -1010 {lab=1.2V}
N 17240 -860 17240 -810 {lab=net2_19}
N 17240 -810 17470 -810 {lab=net2_19}
N 17470 -810 17470 -780 {lab=net2_19}
N 17470 -720 17470 -700 {lab=Vss}
N 17470 -700 17850 -700 {lab=Vss}
N 17850 -1000 17850 -700 {lab=Vss}
N 17290 -670 17470 -670 {lab=Drain[19]}
N 17470 -810 17690 -810 {lab=net2_19}
N 17690 -860 17690 -810 {lab=net2_19}
N 17120 -1130 17390 -1130 {lab=ctrl_p[19]}
N 17430 -860 17530 -860 {lab=ctrl_n[19]}
N 17330 -930 17470 -930 {lab=net1_19}
N 17470 -1030 18370 -1030 {lab=1.2V}
N 17430 -1230 17430 -860 {lab=ctrl_n[19]}
N 17410 -860 17430 -860 {lab=ctrl_n[19]}
N 18100 -830 18270 -830 {lab=Drain[20]}
N 18270 -830 18270 -740 {lab=Drain[20]}
N 18190 -740 18270 -740 {lab=Drain[20]}
N 18100 -830 18100 -740 {lab=Drain[20]}
N 18190 -740 18190 -670 {lab=Drain[20]}
N 18100 -740 18190 -740 {lab=Drain[20]}
N 18370 -670 18560 -670 {lab=Drain[20]}
N 18370 -670 18370 -510 {lab=Drain[20]}
N 18470 -830 18470 -740 {lab=Drain[20]}
N 18560 -740 18640 -740 {lab=Drain[20]}
N 18640 -830 18640 -740 {lab=Drain[20]}
N 18560 -740 18560 -670 {lab=Drain[20]}
N 18470 -740 18560 -740 {lab=Drain[20]}
N 18100 -970 18100 -890 {lab=Dsense}
N 18190 -970 18270 -970 {lab=Dsense}
N 18270 -970 18270 -890 {lab=Dsense}
N 18470 -970 18470 -890 {lab=Dforce}
N 18560 -970 18640 -970 {lab=Dforce}
N 18640 -970 18640 -890 {lab=Dforce}
N 18190 -1090 19090 -1090 {lab=Dsense}
N 18190 -1090 18190 -970 {lab=Dsense}
N 18100 -970 18190 -970 {lab=Dsense}
N 18560 -1060 19460 -1060 {lab=Dforce}
N 18560 -1060 18560 -970 {lab=Dforce}
N 18470 -970 18560 -970 {lab=Dforce}
N 18680 -860 18700 -860 {lab=ctrl_p[20]}
N 18700 -1130 18700 -860 {lab=ctrl_p[20]}
N 18290 -1230 18290 -1130 {lab=ctrl_p[20]}
N 18290 -1130 18700 -1130 {lab=ctrl_p[20]}
N 18020 -1130 18020 -860 {lab=ctrl_p[20]}
N 18020 -860 18060 -860 {lab=ctrl_p[20]}
N 18470 -860 18520 -860 {lab=net1_20}
N 18230 -860 18270 -860 {lab=net1_20}
N 18100 -860 18140 -860 {lab=net2_20}
N 18750 -1000 19650 -1000 {lab=Vss}
N 18590 -860 18640 -860 {lab=net2_20}
N 18370 -950 18370 -930 {lab=net1_20}
N 18370 -930 18520 -930 {lab=net1_20}
N 18230 -930 18230 -860 {lab=net1_20}
N 18520 -930 18520 -860 {lab=net1_20}
N 18370 -1030 18370 -1010 {lab=1.2V}
N 18140 -860 18140 -810 {lab=net2_20}
N 18140 -810 18370 -810 {lab=net2_20}
N 18370 -810 18370 -780 {lab=net2_20}
N 18370 -720 18370 -700 {lab=Vss}
N 18370 -700 18750 -700 {lab=Vss}
N 18750 -1000 18750 -700 {lab=Vss}
N 18190 -670 18370 -670 {lab=Drain[20]}
N 18370 -810 18590 -810 {lab=net2_20}
N 18590 -860 18590 -810 {lab=net2_20}
N 18020 -1130 18290 -1130 {lab=ctrl_p[20]}
N 18330 -860 18430 -860 {lab=ctrl_n[20]}
N 18230 -930 18370 -930 {lab=net1_20}
N 18370 -1030 19270 -1030 {lab=1.2V}
N 18330 -1230 18330 -860 {lab=ctrl_n[20]}
N 18310 -860 18330 -860 {lab=ctrl_n[20]}
N 19000 -830 19170 -830 {lab=Drain[21]}
N 19170 -830 19170 -740 {lab=Drain[21]}
N 19090 -740 19170 -740 {lab=Drain[21]}
N 19000 -830 19000 -740 {lab=Drain[21]}
N 19090 -740 19090 -670 {lab=Drain[21]}
N 19000 -740 19090 -740 {lab=Drain[21]}
N 19270 -670 19460 -670 {lab=Drain[21]}
N 19270 -670 19270 -510 {lab=Drain[21]}
N 19370 -830 19370 -740 {lab=Drain[21]}
N 19460 -740 19540 -740 {lab=Drain[21]}
N 19540 -830 19540 -740 {lab=Drain[21]}
N 19460 -740 19460 -670 {lab=Drain[21]}
N 19370 -740 19460 -740 {lab=Drain[21]}
N 19000 -970 19000 -890 {lab=Dsense}
N 19090 -970 19170 -970 {lab=Dsense}
N 19170 -970 19170 -890 {lab=Dsense}
N 19370 -970 19370 -890 {lab=Dforce}
N 19460 -970 19540 -970 {lab=Dforce}
N 19540 -970 19540 -890 {lab=Dforce}
N 19090 -1090 19990 -1090 {lab=Dsense}
N 19090 -1090 19090 -970 {lab=Dsense}
N 19000 -970 19090 -970 {lab=Dsense}
N 19460 -1060 20360 -1060 {lab=Dforce}
N 19460 -1060 19460 -970 {lab=Dforce}
N 19370 -970 19460 -970 {lab=Dforce}
N 19580 -860 19600 -860 {lab=ctrl_p[21]}
N 19600 -1130 19600 -860 {lab=ctrl_p[21]}
N 19190 -1230 19190 -1130 {lab=ctrl_p[21]}
N 19190 -1130 19600 -1130 {lab=ctrl_p[21]}
N 18920 -1130 18920 -860 {lab=ctrl_p[21]}
N 18920 -860 18960 -860 {lab=ctrl_p[21]}
N 19370 -860 19420 -860 {lab=net1_21}
N 19130 -860 19170 -860 {lab=net1_21}
N 19000 -860 19040 -860 {lab=net2_21}
N 19650 -1000 20550 -1000 {lab=Vss}
N 19490 -860 19540 -860 {lab=net2_21}
N 19270 -950 19270 -930 {lab=net1_21}
N 19270 -930 19420 -930 {lab=net1_21}
N 19130 -930 19130 -860 {lab=net1_21}
N 19420 -930 19420 -860 {lab=net1_21}
N 19270 -1030 19270 -1010 {lab=1.2V}
N 19040 -860 19040 -810 {lab=net2_21}
N 19040 -810 19270 -810 {lab=net2_21}
N 19270 -810 19270 -780 {lab=net2_21}
N 19270 -720 19270 -700 {lab=Vss}
N 19270 -700 19650 -700 {lab=Vss}
N 19650 -1000 19650 -700 {lab=Vss}
N 19090 -670 19270 -670 {lab=Drain[21]}
N 19270 -810 19490 -810 {lab=net2_21}
N 19490 -860 19490 -810 {lab=net2_21}
N 18920 -1130 19190 -1130 {lab=ctrl_p[21]}
N 19230 -860 19330 -860 {lab=ctrl_n[21]}
N 19130 -930 19270 -930 {lab=net1_21}
N 19270 -1030 20170 -1030 {lab=1.2V}
N 19230 -1230 19230 -860 {lab=ctrl_n[21]}
N 19210 -860 19230 -860 {lab=ctrl_n[21]}
N 19900 -830 20070 -830 {lab=Drain[22]}
N 20070 -830 20070 -740 {lab=Drain[22]}
N 19990 -740 20070 -740 {lab=Drain[22]}
N 19900 -830 19900 -740 {lab=Drain[22]}
N 19990 -740 19990 -670 {lab=Drain[22]}
N 19900 -740 19990 -740 {lab=Drain[22]}
N 20170 -670 20360 -670 {lab=Drain[22]}
N 20170 -670 20170 -510 {lab=Drain[22]}
N 20270 -830 20270 -740 {lab=Drain[22]}
N 20360 -740 20440 -740 {lab=Drain[22]}
N 20440 -830 20440 -740 {lab=Drain[22]}
N 20360 -740 20360 -670 {lab=Drain[22]}
N 20270 -740 20360 -740 {lab=Drain[22]}
N 19900 -970 19900 -890 {lab=Dsense}
N 19990 -970 20070 -970 {lab=Dsense}
N 20070 -970 20070 -890 {lab=Dsense}
N 20270 -970 20270 -890 {lab=Dforce}
N 20360 -970 20440 -970 {lab=Dforce}
N 20440 -970 20440 -890 {lab=Dforce}
N 19990 -1090 20890 -1090 {lab=Dsense}
N 19990 -1090 19990 -970 {lab=Dsense}
N 19900 -970 19990 -970 {lab=Dsense}
N 20360 -1060 21260 -1060 {lab=Dforce}
N 20360 -1060 20360 -970 {lab=Dforce}
N 20270 -970 20360 -970 {lab=Dforce}
N 20480 -860 20500 -860 {lab=ctrl_p[22]}
N 20500 -1130 20500 -860 {lab=ctrl_p[22]}
N 20090 -1230 20090 -1130 {lab=ctrl_p[22]}
N 20090 -1130 20500 -1130 {lab=ctrl_p[22]}
N 19820 -1130 19820 -860 {lab=ctrl_p[22]}
N 19820 -860 19860 -860 {lab=ctrl_p[22]}
N 20270 -860 20320 -860 {lab=net1_22}
N 20030 -860 20070 -860 {lab=net1_22}
N 19900 -860 19940 -860 {lab=net2_22}
N 20550 -1000 21450 -1000 {lab=Vss}
N 20390 -860 20440 -860 {lab=net2_22}
N 20170 -950 20170 -930 {lab=net1_22}
N 20170 -930 20320 -930 {lab=net1_22}
N 20030 -930 20030 -860 {lab=net1_22}
N 20320 -930 20320 -860 {lab=net1_22}
N 20170 -1030 20170 -1010 {lab=1.2V}
N 19940 -860 19940 -810 {lab=net2_22}
N 19940 -810 20170 -810 {lab=net2_22}
N 20170 -810 20170 -780 {lab=net2_22}
N 20170 -720 20170 -700 {lab=Vss}
N 20170 -700 20550 -700 {lab=Vss}
N 20550 -1000 20550 -700 {lab=Vss}
N 19990 -670 20170 -670 {lab=Drain[22]}
N 20170 -810 20390 -810 {lab=net2_22}
N 20390 -860 20390 -810 {lab=net2_22}
N 19820 -1130 20090 -1130 {lab=ctrl_p[22]}
N 20130 -860 20230 -860 {lab=ctrl_n[22]}
N 20030 -930 20170 -930 {lab=net1_22}
N 20170 -1030 21070 -1030 {lab=1.2V}
N 20130 -1230 20130 -860 {lab=ctrl_n[22]}
N 20110 -860 20130 -860 {lab=ctrl_n[22]}
N 20800 -830 20970 -830 {lab=Drain[23]}
N 20970 -830 20970 -740 {lab=Drain[23]}
N 20890 -740 20970 -740 {lab=Drain[23]}
N 20800 -830 20800 -740 {lab=Drain[23]}
N 20890 -740 20890 -670 {lab=Drain[23]}
N 20800 -740 20890 -740 {lab=Drain[23]}
N 21070 -670 21260 -670 {lab=Drain[23]}
N 21070 -670 21070 -510 {lab=Drain[23]}
N 21170 -830 21170 -740 {lab=Drain[23]}
N 21260 -740 21340 -740 {lab=Drain[23]}
N 21340 -830 21340 -740 {lab=Drain[23]}
N 21260 -740 21260 -670 {lab=Drain[23]}
N 21170 -740 21260 -740 {lab=Drain[23]}
N 20800 -970 20800 -890 {lab=Dsense}
N 20890 -970 20970 -970 {lab=Dsense}
N 20970 -970 20970 -890 {lab=Dsense}
N 21170 -970 21170 -890 {lab=Dforce}
N 21260 -970 21340 -970 {lab=Dforce}
N 21340 -970 21340 -890 {lab=Dforce}
N 20890 -1090 21790 -1090 {lab=Dsense}
N 20890 -1090 20890 -970 {lab=Dsense}
N 20800 -970 20890 -970 {lab=Dsense}
N 21260 -1060 22160 -1060 {lab=Dforce}
N 21260 -1060 21260 -970 {lab=Dforce}
N 21170 -970 21260 -970 {lab=Dforce}
N 21380 -860 21400 -860 {lab=ctrl_p[23]}
N 21400 -1130 21400 -860 {lab=ctrl_p[23]}
N 20990 -1230 20990 -1130 {lab=ctrl_p[23]}
N 20990 -1130 21400 -1130 {lab=ctrl_p[23]}
N 20720 -1130 20720 -860 {lab=ctrl_p[23]}
N 20720 -860 20760 -860 {lab=ctrl_p[23]}
N 21170 -860 21220 -860 {lab=net1_23}
N 20930 -860 20970 -860 {lab=net1_23}
N 20800 -860 20840 -860 {lab=net2_23}
N 21450 -1000 22350 -1000 {lab=Vss}
N 21290 -860 21340 -860 {lab=net2_23}
N 21070 -950 21070 -930 {lab=net1_23}
N 21070 -930 21220 -930 {lab=net1_23}
N 20930 -930 20930 -860 {lab=net1_23}
N 21220 -930 21220 -860 {lab=net1_23}
N 21070 -1030 21070 -1010 {lab=1.2V}
N 20840 -860 20840 -810 {lab=net2_23}
N 20840 -810 21070 -810 {lab=net2_23}
N 21070 -810 21070 -780 {lab=net2_23}
N 21070 -720 21070 -700 {lab=Vss}
N 21070 -700 21450 -700 {lab=Vss}
N 21450 -1000 21450 -700 {lab=Vss}
N 20890 -670 21070 -670 {lab=Drain[23]}
N 21070 -810 21290 -810 {lab=net2_23}
N 21290 -860 21290 -810 {lab=net2_23}
N 20720 -1130 20990 -1130 {lab=ctrl_p[23]}
N 21030 -860 21130 -860 {lab=ctrl_n[23]}
N 20930 -930 21070 -930 {lab=net1_23}
N 21070 -1030 21970 -1030 {lab=1.2V}
N 21030 -1230 21030 -860 {lab=ctrl_n[23]}
N 21010 -860 21030 -860 {lab=ctrl_n[23]}
N 21700 -830 21870 -830 {lab=Drain[24]}
N 21870 -830 21870 -740 {lab=Drain[24]}
N 21790 -740 21870 -740 {lab=Drain[24]}
N 21700 -830 21700 -740 {lab=Drain[24]}
N 21790 -740 21790 -670 {lab=Drain[24]}
N 21700 -740 21790 -740 {lab=Drain[24]}
N 21970 -670 22160 -670 {lab=Drain[24]}
N 21970 -670 21970 -510 {lab=Drain[24]}
N 22070 -830 22070 -740 {lab=Drain[24]}
N 22160 -740 22240 -740 {lab=Drain[24]}
N 22240 -830 22240 -740 {lab=Drain[24]}
N 22160 -740 22160 -670 {lab=Drain[24]}
N 22070 -740 22160 -740 {lab=Drain[24]}
N 21700 -970 21700 -890 {lab=Dsense}
N 21790 -970 21870 -970 {lab=Dsense}
N 21870 -970 21870 -890 {lab=Dsense}
N 22070 -970 22070 -890 {lab=Dforce}
N 22160 -970 22240 -970 {lab=Dforce}
N 22240 -970 22240 -890 {lab=Dforce}
N 21790 -1090 22690 -1090 {lab=Dsense}
N 21790 -1090 21790 -970 {lab=Dsense}
N 21700 -970 21790 -970 {lab=Dsense}
N 22160 -1060 23060 -1060 {lab=Dforce}
N 22160 -1060 22160 -970 {lab=Dforce}
N 22070 -970 22160 -970 {lab=Dforce}
N 22280 -860 22300 -860 {lab=ctrl_p[24]}
N 22300 -1130 22300 -860 {lab=ctrl_p[24]}
N 21890 -1230 21890 -1130 {lab=ctrl_p[24]}
N 21890 -1130 22300 -1130 {lab=ctrl_p[24]}
N 21620 -1130 21620 -860 {lab=ctrl_p[24]}
N 21620 -860 21660 -860 {lab=ctrl_p[24]}
N 22070 -860 22120 -860 {lab=net1_24}
N 21830 -860 21870 -860 {lab=net1_24}
N 21700 -860 21740 -860 {lab=net2_24}
N 22350 -1000 23250 -1000 {lab=Vss}
N 22190 -860 22240 -860 {lab=net2_24}
N 21970 -950 21970 -930 {lab=net1_24}
N 21970 -930 22120 -930 {lab=net1_24}
N 21830 -930 21830 -860 {lab=net1_24}
N 22120 -930 22120 -860 {lab=net1_24}
N 21970 -1030 21970 -1010 {lab=1.2V}
N 21740 -860 21740 -810 {lab=net2_24}
N 21740 -810 21970 -810 {lab=net2_24}
N 21970 -810 21970 -780 {lab=net2_24}
N 21970 -720 21970 -700 {lab=Vss}
N 21970 -700 22350 -700 {lab=Vss}
N 22350 -1000 22350 -700 {lab=Vss}
N 21790 -670 21970 -670 {lab=Drain[24]}
N 21970 -810 22190 -810 {lab=net2_24}
N 22190 -860 22190 -810 {lab=net2_24}
N 21620 -1130 21890 -1130 {lab=ctrl_p[24]}
N 21930 -860 22030 -860 {lab=ctrl_n[24]}
N 21830 -930 21970 -930 {lab=net1_24}
N 21970 -1030 22870 -1030 {lab=1.2V}
N 21930 -1230 21930 -860 {lab=ctrl_n[24]}
N 21910 -860 21930 -860 {lab=ctrl_n[24]}
N 22600 -830 22770 -830 {lab=Drain[25]}
N 22770 -830 22770 -740 {lab=Drain[25]}
N 22690 -740 22770 -740 {lab=Drain[25]}
N 22600 -830 22600 -740 {lab=Drain[25]}
N 22690 -740 22690 -670 {lab=Drain[25]}
N 22600 -740 22690 -740 {lab=Drain[25]}
N 22870 -670 23060 -670 {lab=Drain[25]}
N 22870 -670 22870 -510 {lab=Drain[25]}
N 22970 -830 22970 -740 {lab=Drain[25]}
N 23060 -740 23140 -740 {lab=Drain[25]}
N 23140 -830 23140 -740 {lab=Drain[25]}
N 23060 -740 23060 -670 {lab=Drain[25]}
N 22970 -740 23060 -740 {lab=Drain[25]}
N 22600 -970 22600 -890 {lab=Dsense}
N 22690 -970 22770 -970 {lab=Dsense}
N 22770 -970 22770 -890 {lab=Dsense}
N 22970 -970 22970 -890 {lab=Dforce}
N 23060 -970 23140 -970 {lab=Dforce}
N 23140 -970 23140 -890 {lab=Dforce}
N 22690 -1090 23590 -1090 {lab=Dsense}
N 22690 -1090 22690 -970 {lab=Dsense}
N 22600 -970 22690 -970 {lab=Dsense}
N 23060 -1060 23960 -1060 {lab=Dforce}
N 23060 -1060 23060 -970 {lab=Dforce}
N 22970 -970 23060 -970 {lab=Dforce}
N 23180 -860 23200 -860 {lab=ctrl_p[25]}
N 23200 -1130 23200 -860 {lab=ctrl_p[25]}
N 22790 -1230 22790 -1130 {lab=ctrl_p[25]}
N 22790 -1130 23200 -1130 {lab=ctrl_p[25]}
N 22520 -1130 22520 -860 {lab=ctrl_p[25]}
N 22520 -860 22560 -860 {lab=ctrl_p[25]}
N 22970 -860 23020 -860 {lab=net1_25}
N 22730 -860 22770 -860 {lab=net1_25}
N 22600 -860 22640 -860 {lab=net2_25}
N 23250 -1000 24150 -1000 {lab=Vss}
N 23090 -860 23140 -860 {lab=net2_25}
N 22870 -950 22870 -930 {lab=net1_25}
N 22870 -930 23020 -930 {lab=net1_25}
N 22730 -930 22730 -860 {lab=net1_25}
N 23020 -930 23020 -860 {lab=net1_25}
N 22870 -1030 22870 -1010 {lab=1.2V}
N 22640 -860 22640 -810 {lab=net2_25}
N 22640 -810 22870 -810 {lab=net2_25}
N 22870 -810 22870 -780 {lab=net2_25}
N 22870 -720 22870 -700 {lab=Vss}
N 22870 -700 23250 -700 {lab=Vss}
N 23250 -1000 23250 -700 {lab=Vss}
N 22690 -670 22870 -670 {lab=Drain[25]}
N 22870 -810 23090 -810 {lab=net2_25}
N 23090 -860 23090 -810 {lab=net2_25}
N 22520 -1130 22790 -1130 {lab=ctrl_p[25]}
N 22830 -860 22930 -860 {lab=ctrl_n[25]}
N 22730 -930 22870 -930 {lab=net1_25}
N 22870 -1030 23770 -1030 {lab=1.2V}
N 22830 -1230 22830 -860 {lab=ctrl_n[25]}
N 22810 -860 22830 -860 {lab=ctrl_n[25]}
N 23500 -830 23670 -830 {lab=Drain[26]}
N 23670 -830 23670 -740 {lab=Drain[26]}
N 23590 -740 23670 -740 {lab=Drain[26]}
N 23500 -830 23500 -740 {lab=Drain[26]}
N 23590 -740 23590 -670 {lab=Drain[26]}
N 23500 -740 23590 -740 {lab=Drain[26]}
N 23770 -670 23960 -670 {lab=Drain[26]}
N 23770 -670 23770 -510 {lab=Drain[26]}
N 23870 -830 23870 -740 {lab=Drain[26]}
N 23960 -740 24040 -740 {lab=Drain[26]}
N 24040 -830 24040 -740 {lab=Drain[26]}
N 23960 -740 23960 -670 {lab=Drain[26]}
N 23870 -740 23960 -740 {lab=Drain[26]}
N 23500 -970 23500 -890 {lab=Dsense}
N 23590 -970 23670 -970 {lab=Dsense}
N 23670 -970 23670 -890 {lab=Dsense}
N 23870 -970 23870 -890 {lab=Dforce}
N 23960 -970 24040 -970 {lab=Dforce}
N 24040 -970 24040 -890 {lab=Dforce}
N 23590 -1090 24490 -1090 {lab=Dsense}
N 23590 -1090 23590 -970 {lab=Dsense}
N 23500 -970 23590 -970 {lab=Dsense}
N 23960 -1060 24860 -1060 {lab=Dforce}
N 23960 -1060 23960 -970 {lab=Dforce}
N 23870 -970 23960 -970 {lab=Dforce}
N 24080 -860 24100 -860 {lab=ctrl_p[26]}
N 24100 -1130 24100 -860 {lab=ctrl_p[26]}
N 23690 -1230 23690 -1130 {lab=ctrl_p[26]}
N 23690 -1130 24100 -1130 {lab=ctrl_p[26]}
N 23420 -1130 23420 -860 {lab=ctrl_p[26]}
N 23420 -860 23460 -860 {lab=ctrl_p[26]}
N 23870 -860 23920 -860 {lab=net1_26}
N 23630 -860 23670 -860 {lab=net1_26}
N 23500 -860 23540 -860 {lab=net2_26}
N 24150 -1000 25050 -1000 {lab=Vss}
N 23990 -860 24040 -860 {lab=net2_26}
N 23770 -950 23770 -930 {lab=net1_26}
N 23770 -930 23920 -930 {lab=net1_26}
N 23630 -930 23630 -860 {lab=net1_26}
N 23920 -930 23920 -860 {lab=net1_26}
N 23770 -1030 23770 -1010 {lab=1.2V}
N 23540 -860 23540 -810 {lab=net2_26}
N 23540 -810 23770 -810 {lab=net2_26}
N 23770 -810 23770 -780 {lab=net2_26}
N 23770 -720 23770 -700 {lab=Vss}
N 23770 -700 24150 -700 {lab=Vss}
N 24150 -1000 24150 -700 {lab=Vss}
N 23590 -670 23770 -670 {lab=Drain[26]}
N 23770 -810 23990 -810 {lab=net2_26}
N 23990 -860 23990 -810 {lab=net2_26}
N 23420 -1130 23690 -1130 {lab=ctrl_p[26]}
N 23730 -860 23830 -860 {lab=ctrl_n[26]}
N 23630 -930 23770 -930 {lab=net1_26}
N 23770 -1030 24670 -1030 {lab=1.2V}
N 23730 -1230 23730 -860 {lab=ctrl_n[26]}
N 23710 -860 23730 -860 {lab=ctrl_n[26]}
N 24400 -830 24570 -830 {lab=Drain[27]}
N 24570 -830 24570 -740 {lab=Drain[27]}
N 24490 -740 24570 -740 {lab=Drain[27]}
N 24400 -830 24400 -740 {lab=Drain[27]}
N 24490 -740 24490 -670 {lab=Drain[27]}
N 24400 -740 24490 -740 {lab=Drain[27]}
N 24670 -670 24860 -670 {lab=Drain[27]}
N 24670 -670 24670 -510 {lab=Drain[27]}
N 24770 -830 24770 -740 {lab=Drain[27]}
N 24860 -740 24940 -740 {lab=Drain[27]}
N 24940 -830 24940 -740 {lab=Drain[27]}
N 24860 -740 24860 -670 {lab=Drain[27]}
N 24770 -740 24860 -740 {lab=Drain[27]}
N 24400 -970 24400 -890 {lab=Dsense}
N 24490 -970 24570 -970 {lab=Dsense}
N 24570 -970 24570 -890 {lab=Dsense}
N 24770 -970 24770 -890 {lab=Dforce}
N 24860 -970 24940 -970 {lab=Dforce}
N 24940 -970 24940 -890 {lab=Dforce}
N 24490 -1090 25390 -1090 {lab=Dsense}
N 24490 -1090 24490 -970 {lab=Dsense}
N 24400 -970 24490 -970 {lab=Dsense}
N 24860 -1060 25760 -1060 {lab=Dforce}
N 24860 -1060 24860 -970 {lab=Dforce}
N 24770 -970 24860 -970 {lab=Dforce}
N 24980 -860 25000 -860 {lab=ctrl_p[27]}
N 25000 -1130 25000 -860 {lab=ctrl_p[27]}
N 24590 -1230 24590 -1130 {lab=ctrl_p[27]}
N 24590 -1130 25000 -1130 {lab=ctrl_p[27]}
N 24320 -1130 24320 -860 {lab=ctrl_p[27]}
N 24320 -860 24360 -860 {lab=ctrl_p[27]}
N 24770 -860 24820 -860 {lab=net1_27}
N 24530 -860 24570 -860 {lab=net1_27}
N 24400 -860 24440 -860 {lab=net2_27}
N 25050 -1000 25950 -1000 {lab=Vss}
N 24890 -860 24940 -860 {lab=net2_27}
N 24670 -950 24670 -930 {lab=net1_27}
N 24670 -930 24820 -930 {lab=net1_27}
N 24530 -930 24530 -860 {lab=net1_27}
N 24820 -930 24820 -860 {lab=net1_27}
N 24670 -1030 24670 -1010 {lab=1.2V}
N 24440 -860 24440 -810 {lab=net2_27}
N 24440 -810 24670 -810 {lab=net2_27}
N 24670 -810 24670 -780 {lab=net2_27}
N 24670 -720 24670 -700 {lab=Vss}
N 24670 -700 25050 -700 {lab=Vss}
N 25050 -1000 25050 -700 {lab=Vss}
N 24490 -670 24670 -670 {lab=Drain[27]}
N 24670 -810 24890 -810 {lab=net2_27}
N 24890 -860 24890 -810 {lab=net2_27}
N 24320 -1130 24590 -1130 {lab=ctrl_p[27]}
N 24630 -860 24730 -860 {lab=ctrl_n[27]}
N 24530 -930 24670 -930 {lab=net1_27}
N 24670 -1030 25570 -1030 {lab=1.2V}
N 24630 -1230 24630 -860 {lab=ctrl_n[27]}
N 24610 -860 24630 -860 {lab=ctrl_n[27]}
N 25300 -830 25470 -830 {lab=Drain[28]}
N 25470 -830 25470 -740 {lab=Drain[28]}
N 25390 -740 25470 -740 {lab=Drain[28]}
N 25300 -830 25300 -740 {lab=Drain[28]}
N 25390 -740 25390 -670 {lab=Drain[28]}
N 25300 -740 25390 -740 {lab=Drain[28]}
N 25570 -670 25760 -670 {lab=Drain[28]}
N 25570 -670 25570 -510 {lab=Drain[28]}
N 25670 -830 25670 -740 {lab=Drain[28]}
N 25760 -740 25840 -740 {lab=Drain[28]}
N 25840 -830 25840 -740 {lab=Drain[28]}
N 25760 -740 25760 -670 {lab=Drain[28]}
N 25670 -740 25760 -740 {lab=Drain[28]}
N 25300 -970 25300 -890 {lab=Dsense}
N 25390 -970 25470 -970 {lab=Dsense}
N 25470 -970 25470 -890 {lab=Dsense}
N 25670 -970 25670 -890 {lab=Dforce}
N 25760 -970 25840 -970 {lab=Dforce}
N 25840 -970 25840 -890 {lab=Dforce}
N 25390 -1090 26290 -1090 {lab=Dsense}
N 25390 -1090 25390 -970 {lab=Dsense}
N 25300 -970 25390 -970 {lab=Dsense}
N 25760 -1060 26660 -1060 {lab=Dforce}
N 25760 -1060 25760 -970 {lab=Dforce}
N 25670 -970 25760 -970 {lab=Dforce}
N 25880 -860 25900 -860 {lab=ctrl_p[28]}
N 25900 -1130 25900 -860 {lab=ctrl_p[28]}
N 25490 -1230 25490 -1130 {lab=ctrl_p[28]}
N 25490 -1130 25900 -1130 {lab=ctrl_p[28]}
N 25220 -1130 25220 -860 {lab=ctrl_p[28]}
N 25220 -860 25260 -860 {lab=ctrl_p[28]}
N 25670 -860 25720 -860 {lab=net1_28}
N 25430 -860 25470 -860 {lab=net1_28}
N 25300 -860 25340 -860 {lab=net2_28}
N 25950 -1000 26850 -1000 {lab=Vss}
N 25790 -860 25840 -860 {lab=net2_28}
N 25570 -950 25570 -930 {lab=net1_28}
N 25570 -930 25720 -930 {lab=net1_28}
N 25430 -930 25430 -860 {lab=net1_28}
N 25720 -930 25720 -860 {lab=net1_28}
N 25570 -1030 25570 -1010 {lab=1.2V}
N 25340 -860 25340 -810 {lab=net2_28}
N 25340 -810 25570 -810 {lab=net2_28}
N 25570 -810 25570 -780 {lab=net2_28}
N 25570 -720 25570 -700 {lab=Vss}
N 25570 -700 25950 -700 {lab=Vss}
N 25950 -1000 25950 -700 {lab=Vss}
N 25390 -670 25570 -670 {lab=Drain[28]}
N 25570 -810 25790 -810 {lab=net2_28}
N 25790 -860 25790 -810 {lab=net2_28}
N 25220 -1130 25490 -1130 {lab=ctrl_p[28]}
N 25530 -860 25630 -860 {lab=ctrl_n[28]}
N 25430 -930 25570 -930 {lab=net1_28}
N 25570 -1030 26470 -1030 {lab=1.2V}
N 25530 -1230 25530 -860 {lab=ctrl_n[28]}
N 25510 -860 25530 -860 {lab=ctrl_n[28]}
N 26200 -830 26370 -830 {lab=Drain[29]}
N 26370 -830 26370 -740 {lab=Drain[29]}
N 26290 -740 26370 -740 {lab=Drain[29]}
N 26200 -830 26200 -740 {lab=Drain[29]}
N 26290 -740 26290 -670 {lab=Drain[29]}
N 26200 -740 26290 -740 {lab=Drain[29]}
N 26470 -670 26660 -670 {lab=Drain[29]}
N 26470 -670 26470 -510 {lab=Drain[29]}
N 26570 -830 26570 -740 {lab=Drain[29]}
N 26660 -740 26740 -740 {lab=Drain[29]}
N 26740 -830 26740 -740 {lab=Drain[29]}
N 26660 -740 26660 -670 {lab=Drain[29]}
N 26570 -740 26660 -740 {lab=Drain[29]}
N 26200 -970 26200 -890 {lab=Dsense}
N 26290 -970 26370 -970 {lab=Dsense}
N 26370 -970 26370 -890 {lab=Dsense}
N 26570 -970 26570 -890 {lab=Dforce}
N 26660 -970 26740 -970 {lab=Dforce}
N 26740 -970 26740 -890 {lab=Dforce}
N 26290 -1090 27190 -1090 {lab=Dsense}
N 26290 -1090 26290 -970 {lab=Dsense}
N 26200 -970 26290 -970 {lab=Dsense}
N 26660 -1060 27560 -1060 {lab=Dforce}
N 26660 -1060 26660 -970 {lab=Dforce}
N 26570 -970 26660 -970 {lab=Dforce}
N 26780 -860 26800 -860 {lab=ctrl_p[29]}
N 26800 -1130 26800 -860 {lab=ctrl_p[29]}
N 26390 -1230 26390 -1130 {lab=ctrl_p[29]}
N 26390 -1130 26800 -1130 {lab=ctrl_p[29]}
N 26120 -1130 26120 -860 {lab=ctrl_p[29]}
N 26120 -860 26160 -860 {lab=ctrl_p[29]}
N 26570 -860 26620 -860 {lab=net1_29}
N 26330 -860 26370 -860 {lab=net1_29}
N 26200 -860 26240 -860 {lab=net2_29}
N 26850 -1000 27750 -1000 {lab=Vss}
N 26690 -860 26740 -860 {lab=net2_29}
N 26470 -950 26470 -930 {lab=net1_29}
N 26470 -930 26620 -930 {lab=net1_29}
N 26330 -930 26330 -860 {lab=net1_29}
N 26620 -930 26620 -860 {lab=net1_29}
N 26470 -1030 26470 -1010 {lab=1.2V}
N 26240 -860 26240 -810 {lab=net2_29}
N 26240 -810 26470 -810 {lab=net2_29}
N 26470 -810 26470 -780 {lab=net2_29}
N 26470 -720 26470 -700 {lab=Vss}
N 26470 -700 26850 -700 {lab=Vss}
N 26850 -1000 26850 -700 {lab=Vss}
N 26290 -670 26470 -670 {lab=Drain[29]}
N 26470 -810 26690 -810 {lab=net2_29}
N 26690 -860 26690 -810 {lab=net2_29}
N 26120 -1130 26390 -1130 {lab=ctrl_p[29]}
N 26430 -860 26530 -860 {lab=ctrl_n[29]}
N 26330 -930 26470 -930 {lab=net1_29}
N 26470 -1030 27370 -1030 {lab=1.2V}
N 26430 -1230 26430 -860 {lab=ctrl_n[29]}
N 26410 -860 26430 -860 {lab=ctrl_n[29]}
N 27100 -830 27270 -830 {lab=Drain[30]}
N 27270 -830 27270 -740 {lab=Drain[30]}
N 27190 -740 27270 -740 {lab=Drain[30]}
N 27100 -830 27100 -740 {lab=Drain[30]}
N 27190 -740 27190 -670 {lab=Drain[30]}
N 27100 -740 27190 -740 {lab=Drain[30]}
N 27370 -670 27560 -670 {lab=Drain[30]}
N 27370 -670 27370 -510 {lab=Drain[30]}
N 27470 -830 27470 -740 {lab=Drain[30]}
N 27560 -740 27640 -740 {lab=Drain[30]}
N 27640 -830 27640 -740 {lab=Drain[30]}
N 27560 -740 27560 -670 {lab=Drain[30]}
N 27470 -740 27560 -740 {lab=Drain[30]}
N 27100 -970 27100 -890 {lab=Dsense}
N 27190 -970 27270 -970 {lab=Dsense}
N 27270 -970 27270 -890 {lab=Dsense}
N 27470 -970 27470 -890 {lab=Dforce}
N 27560 -970 27640 -970 {lab=Dforce}
N 27640 -970 27640 -890 {lab=Dforce}
N 27190 -1090 28090 -1090 {lab=Dsense}
N 27190 -1090 27190 -970 {lab=Dsense}
N 27100 -970 27190 -970 {lab=Dsense}
N 27560 -1060 28460 -1060 {lab=Dforce}
N 27560 -1060 27560 -970 {lab=Dforce}
N 27470 -970 27560 -970 {lab=Dforce}
N 27680 -860 27700 -860 {lab=ctrl_p[30]}
N 27700 -1130 27700 -860 {lab=ctrl_p[30]}
N 27290 -1230 27290 -1130 {lab=ctrl_p[30]}
N 27290 -1130 27700 -1130 {lab=ctrl_p[30]}
N 27020 -1130 27020 -860 {lab=ctrl_p[30]}
N 27020 -860 27060 -860 {lab=ctrl_p[30]}
N 27470 -860 27520 -860 {lab=net1_30}
N 27230 -860 27270 -860 {lab=net1_30}
N 27100 -860 27140 -860 {lab=net2_30}
N 27750 -1000 28650 -1000 {lab=Vss}
N 27590 -860 27640 -860 {lab=net2_30}
N 27370 -950 27370 -930 {lab=net1_30}
N 27370 -930 27520 -930 {lab=net1_30}
N 27230 -930 27230 -860 {lab=net1_30}
N 27520 -930 27520 -860 {lab=net1_30}
N 27370 -1030 27370 -1010 {lab=1.2V}
N 27140 -860 27140 -810 {lab=net2_30}
N 27140 -810 27370 -810 {lab=net2_30}
N 27370 -810 27370 -780 {lab=net2_30}
N 27370 -720 27370 -700 {lab=Vss}
N 27370 -700 27750 -700 {lab=Vss}
N 27750 -1000 27750 -700 {lab=Vss}
N 27190 -670 27370 -670 {lab=Drain[30]}
N 27370 -810 27590 -810 {lab=net2_30}
N 27590 -860 27590 -810 {lab=net2_30}
N 27020 -1130 27290 -1130 {lab=ctrl_p[30]}
N 27330 -860 27430 -860 {lab=ctrl_n[30]}
N 27230 -930 27370 -930 {lab=net1_30}
N 27370 -1030 28270 -1030 {lab=1.2V}
N 27330 -1230 27330 -860 {lab=ctrl_n[30]}
N 27310 -860 27330 -860 {lab=ctrl_n[30]}
N 28000 -830 28170 -830 {lab=Drain[31]}
N 28170 -830 28170 -740 {lab=Drain[31]}
N 28090 -740 28170 -740 {lab=Drain[31]}
N 28000 -830 28000 -740 {lab=Drain[31]}
N 28090 -740 28090 -670 {lab=Drain[31]}
N 28000 -740 28090 -740 {lab=Drain[31]}
N 28270 -670 28460 -670 {lab=Drain[31]}
N 28270 -670 28270 -510 {lab=Drain[31]}
N 28370 -830 28370 -740 {lab=Drain[31]}
N 28460 -740 28540 -740 {lab=Drain[31]}
N 28540 -830 28540 -740 {lab=Drain[31]}
N 28460 -740 28460 -670 {lab=Drain[31]}
N 28370 -740 28460 -740 {lab=Drain[31]}
N 28000 -970 28000 -890 {lab=Dsense}
N 28090 -970 28170 -970 {lab=Dsense}
N 28170 -970 28170 -890 {lab=Dsense}
N 28370 -970 28370 -890 {lab=Dforce}
N 28460 -970 28540 -970 {lab=Dforce}
N 28540 -970 28540 -890 {lab=Dforce}
N 28090 -1090 28990 -1090 {lab=Dsense}
N 28090 -1090 28090 -970 {lab=Dsense}
N 28000 -970 28090 -970 {lab=Dsense}
N 28460 -1060 29360 -1060 {lab=Dforce}
N 28460 -1060 28460 -970 {lab=Dforce}
N 28370 -970 28460 -970 {lab=Dforce}
N 28580 -860 28600 -860 {lab=ctrl_p[31]}
N 28600 -1130 28600 -860 {lab=ctrl_p[31]}
N 28190 -1230 28190 -1130 {lab=ctrl_p[31]}
N 28190 -1130 28600 -1130 {lab=ctrl_p[31]}
N 27920 -1130 27920 -860 {lab=ctrl_p[31]}
N 27920 -860 27960 -860 {lab=ctrl_p[31]}
N 28370 -860 28420 -860 {lab=net1_31}
N 28130 -860 28170 -860 {lab=net1_31}
N 28000 -860 28040 -860 {lab=net2_31}
N 28650 -1000 29550 -1000 {lab=Vss}
N 28490 -860 28540 -860 {lab=net2_31}
N 28270 -950 28270 -930 {lab=net1_31}
N 28270 -930 28420 -930 {lab=net1_31}
N 28130 -930 28130 -860 {lab=net1_31}
N 28420 -930 28420 -860 {lab=net1_31}
N 28270 -1030 28270 -1010 {lab=1.2V}
N 28040 -860 28040 -810 {lab=net2_31}
N 28040 -810 28270 -810 {lab=net2_31}
N 28270 -810 28270 -780 {lab=net2_31}
N 28270 -720 28270 -700 {lab=Vss}
N 28270 -700 28650 -700 {lab=Vss}
N 28650 -1000 28650 -700 {lab=Vss}
N 28090 -670 28270 -670 {lab=Drain[31]}
N 28270 -810 28490 -810 {lab=net2_31}
N 28490 -860 28490 -810 {lab=net2_31}
N 27920 -1130 28190 -1130 {lab=ctrl_p[31]}
N 28230 -860 28330 -860 {lab=ctrl_n[31]}
N 28130 -930 28270 -930 {lab=net1_31}
N 28270 -1030 29170 -1030 {lab=1.2V}
N 28230 -1230 28230 -860 {lab=ctrl_n[31]}
N 28210 -860 28230 -860 {lab=ctrl_n[31]}
N 28900 -830 29070 -830 {lab=Drain[32]}
N 29070 -830 29070 -740 {lab=Drain[32]}
N 28990 -740 29070 -740 {lab=Drain[32]}
N 28900 -830 28900 -740 {lab=Drain[32]}
N 28990 -740 28990 -670 {lab=Drain[32]}
N 28900 -740 28990 -740 {lab=Drain[32]}
N 29170 -670 29360 -670 {lab=Drain[32]}
N 29170 -670 29170 -510 {lab=Drain[32]}
N 29270 -830 29270 -740 {lab=Drain[32]}
N 29360 -740 29440 -740 {lab=Drain[32]}
N 29440 -830 29440 -740 {lab=Drain[32]}
N 29360 -740 29360 -670 {lab=Drain[32]}
N 29270 -740 29360 -740 {lab=Drain[32]}
N 28900 -970 28900 -890 {lab=Dsense}
N 28990 -970 29070 -970 {lab=Dsense}
N 29070 -970 29070 -890 {lab=Dsense}
N 29270 -970 29270 -890 {lab=Dforce}
N 29360 -970 29440 -970 {lab=Dforce}
N 29440 -970 29440 -890 {lab=Dforce}
N 28990 -1090 29890 -1090 {lab=Dsense}
N 28990 -1090 28990 -970 {lab=Dsense}
N 28900 -970 28990 -970 {lab=Dsense}
N 29360 -1060 30260 -1060 {lab=Dforce}
N 29360 -1060 29360 -970 {lab=Dforce}
N 29270 -970 29360 -970 {lab=Dforce}
N 29480 -860 29500 -860 {lab=ctrl_p[32]}
N 29500 -1130 29500 -860 {lab=ctrl_p[32]}
N 29090 -1230 29090 -1130 {lab=ctrl_p[32]}
N 29090 -1130 29500 -1130 {lab=ctrl_p[32]}
N 28820 -1130 28820 -860 {lab=ctrl_p[32]}
N 28820 -860 28860 -860 {lab=ctrl_p[32]}
N 29270 -860 29320 -860 {lab=net1_32}
N 29030 -860 29070 -860 {lab=net1_32}
N 28900 -860 28940 -860 {lab=net2_32}
N 29550 -1000 30450 -1000 {lab=Vss}
N 29390 -860 29440 -860 {lab=net2_32}
N 29170 -950 29170 -930 {lab=net1_32}
N 29170 -930 29320 -930 {lab=net1_32}
N 29030 -930 29030 -860 {lab=net1_32}
N 29320 -930 29320 -860 {lab=net1_32}
N 29170 -1030 29170 -1010 {lab=1.2V}
N 28940 -860 28940 -810 {lab=net2_32}
N 28940 -810 29170 -810 {lab=net2_32}
N 29170 -810 29170 -780 {lab=net2_32}
N 29170 -720 29170 -700 {lab=Vss}
N 29170 -700 29550 -700 {lab=Vss}
N 29550 -1000 29550 -700 {lab=Vss}
N 28990 -670 29170 -670 {lab=Drain[32]}
N 29170 -810 29390 -810 {lab=net2_32}
N 29390 -860 29390 -810 {lab=net2_32}
N 28820 -1130 29090 -1130 {lab=ctrl_p[32]}
N 29130 -860 29230 -860 {lab=ctrl_n[32]}
N 29030 -930 29170 -930 {lab=net1_32}
N 29170 -1030 30070 -1030 {lab=1.2V}
N 29130 -1230 29130 -860 {lab=ctrl_n[32]}
N 29110 -860 29130 -860 {lab=ctrl_n[32]}
N 29800 -830 29970 -830 {lab=Drain[33]}
N 29970 -830 29970 -740 {lab=Drain[33]}
N 29890 -740 29970 -740 {lab=Drain[33]}
N 29800 -830 29800 -740 {lab=Drain[33]}
N 29890 -740 29890 -670 {lab=Drain[33]}
N 29800 -740 29890 -740 {lab=Drain[33]}
N 30070 -670 30260 -670 {lab=Drain[33]}
N 30070 -670 30070 -510 {lab=Drain[33]}
N 30170 -830 30170 -740 {lab=Drain[33]}
N 30260 -740 30340 -740 {lab=Drain[33]}
N 30340 -830 30340 -740 {lab=Drain[33]}
N 30260 -740 30260 -670 {lab=Drain[33]}
N 30170 -740 30260 -740 {lab=Drain[33]}
N 29800 -970 29800 -890 {lab=Dsense}
N 29890 -970 29970 -970 {lab=Dsense}
N 29970 -970 29970 -890 {lab=Dsense}
N 30170 -970 30170 -890 {lab=Dforce}
N 30260 -970 30340 -970 {lab=Dforce}
N 30340 -970 30340 -890 {lab=Dforce}
N 29890 -1090 30790 -1090 {lab=Dsense}
N 29890 -1090 29890 -970 {lab=Dsense}
N 29800 -970 29890 -970 {lab=Dsense}
N 30260 -1060 31160 -1060 {lab=Dforce}
N 30260 -1060 30260 -970 {lab=Dforce}
N 30170 -970 30260 -970 {lab=Dforce}
N 30380 -860 30400 -860 {lab=ctrl_p[33]}
N 30400 -1130 30400 -860 {lab=ctrl_p[33]}
N 29990 -1230 29990 -1130 {lab=ctrl_p[33]}
N 29990 -1130 30400 -1130 {lab=ctrl_p[33]}
N 29720 -1130 29720 -860 {lab=ctrl_p[33]}
N 29720 -860 29760 -860 {lab=ctrl_p[33]}
N 30170 -860 30220 -860 {lab=net1_33}
N 29930 -860 29970 -860 {lab=net1_33}
N 29800 -860 29840 -860 {lab=net2_33}
N 30450 -1000 31350 -1000 {lab=Vss}
N 30290 -860 30340 -860 {lab=net2_33}
N 30070 -950 30070 -930 {lab=net1_33}
N 30070 -930 30220 -930 {lab=net1_33}
N 29930 -930 29930 -860 {lab=net1_33}
N 30220 -930 30220 -860 {lab=net1_33}
N 30070 -1030 30070 -1010 {lab=1.2V}
N 29840 -860 29840 -810 {lab=net2_33}
N 29840 -810 30070 -810 {lab=net2_33}
N 30070 -810 30070 -780 {lab=net2_33}
N 30070 -720 30070 -700 {lab=Vss}
N 30070 -700 30450 -700 {lab=Vss}
N 30450 -1000 30450 -700 {lab=Vss}
N 29890 -670 30070 -670 {lab=Drain[33]}
N 30070 -810 30290 -810 {lab=net2_33}
N 30290 -860 30290 -810 {lab=net2_33}
N 29720 -1130 29990 -1130 {lab=ctrl_p[33]}
N 30030 -860 30130 -860 {lab=ctrl_n[33]}
N 29930 -930 30070 -930 {lab=net1_33}
N 30070 -1030 30970 -1030 {lab=1.2V}
N 30030 -1230 30030 -860 {lab=ctrl_n[33]}
N 30010 -860 30030 -860 {lab=ctrl_n[33]}
N 30700 -830 30870 -830 {lab=Drain[34]}
N 30870 -830 30870 -740 {lab=Drain[34]}
N 30790 -740 30870 -740 {lab=Drain[34]}
N 30700 -830 30700 -740 {lab=Drain[34]}
N 30790 -740 30790 -670 {lab=Drain[34]}
N 30700 -740 30790 -740 {lab=Drain[34]}
N 30970 -670 31160 -670 {lab=Drain[34]}
N 30970 -670 30970 -510 {lab=Drain[34]}
N 31070 -830 31070 -740 {lab=Drain[34]}
N 31160 -740 31240 -740 {lab=Drain[34]}
N 31240 -830 31240 -740 {lab=Drain[34]}
N 31160 -740 31160 -670 {lab=Drain[34]}
N 31070 -740 31160 -740 {lab=Drain[34]}
N 30700 -970 30700 -890 {lab=Dsense}
N 30790 -970 30870 -970 {lab=Dsense}
N 30870 -970 30870 -890 {lab=Dsense}
N 31070 -970 31070 -890 {lab=Dforce}
N 31160 -970 31240 -970 {lab=Dforce}
N 31240 -970 31240 -890 {lab=Dforce}
N 30790 -1090 31690 -1090 {lab=Dsense}
N 30790 -1090 30790 -970 {lab=Dsense}
N 30700 -970 30790 -970 {lab=Dsense}
N 31160 -1060 32060 -1060 {lab=Dforce}
N 31160 -1060 31160 -970 {lab=Dforce}
N 31070 -970 31160 -970 {lab=Dforce}
N 31280 -860 31300 -860 {lab=ctrl_p[34]}
N 31300 -1130 31300 -860 {lab=ctrl_p[34]}
N 30890 -1230 30890 -1130 {lab=ctrl_p[34]}
N 30890 -1130 31300 -1130 {lab=ctrl_p[34]}
N 30620 -1130 30620 -860 {lab=ctrl_p[34]}
N 30620 -860 30660 -860 {lab=ctrl_p[34]}
N 31070 -860 31120 -860 {lab=net1_34}
N 30830 -860 30870 -860 {lab=net1_34}
N 30700 -860 30740 -860 {lab=net2_34}
N 31350 -1000 32250 -1000 {lab=Vss}
N 31190 -860 31240 -860 {lab=net2_34}
N 30970 -950 30970 -930 {lab=net1_34}
N 30970 -930 31120 -930 {lab=net1_34}
N 30830 -930 30830 -860 {lab=net1_34}
N 31120 -930 31120 -860 {lab=net1_34}
N 30970 -1030 30970 -1010 {lab=1.2V}
N 30740 -860 30740 -810 {lab=net2_34}
N 30740 -810 30970 -810 {lab=net2_34}
N 30970 -810 30970 -780 {lab=net2_34}
N 30970 -720 30970 -700 {lab=Vss}
N 30970 -700 31350 -700 {lab=Vss}
N 31350 -1000 31350 -700 {lab=Vss}
N 30790 -670 30970 -670 {lab=Drain[34]}
N 30970 -810 31190 -810 {lab=net2_34}
N 31190 -860 31190 -810 {lab=net2_34}
N 30620 -1130 30890 -1130 {lab=ctrl_p[34]}
N 30930 -860 31030 -860 {lab=ctrl_n[34]}
N 30830 -930 30970 -930 {lab=net1_34}
N 30970 -1030 31870 -1030 {lab=1.2V}
N 30930 -1230 30930 -860 {lab=ctrl_n[34]}
N 30910 -860 30930 -860 {lab=ctrl_n[34]}
N 31600 -830 31770 -830 {lab=Drain[35]}
N 31770 -830 31770 -740 {lab=Drain[35]}
N 31690 -740 31770 -740 {lab=Drain[35]}
N 31600 -830 31600 -740 {lab=Drain[35]}
N 31690 -740 31690 -670 {lab=Drain[35]}
N 31600 -740 31690 -740 {lab=Drain[35]}
N 31870 -670 32060 -670 {lab=Drain[35]}
N 31870 -670 31870 -510 {lab=Drain[35]}
N 31970 -830 31970 -740 {lab=Drain[35]}
N 32060 -740 32140 -740 {lab=Drain[35]}
N 32140 -830 32140 -740 {lab=Drain[35]}
N 32060 -740 32060 -670 {lab=Drain[35]}
N 31970 -740 32060 -740 {lab=Drain[35]}
N 31600 -970 31600 -890 {lab=Dsense}
N 31690 -970 31770 -970 {lab=Dsense}
N 31770 -970 31770 -890 {lab=Dsense}
N 31970 -970 31970 -890 {lab=Dforce}
N 32060 -970 32140 -970 {lab=Dforce}
N 32140 -970 32140 -890 {lab=Dforce}
N 31690 -1090 32590 -1090 {lab=Dsense}
N 31690 -1090 31690 -970 {lab=Dsense}
N 31600 -970 31690 -970 {lab=Dsense}
N 32060 -1060 32960 -1060 {lab=Dforce}
N 32060 -1060 32060 -970 {lab=Dforce}
N 31970 -970 32060 -970 {lab=Dforce}
N 32180 -860 32200 -860 {lab=ctrl_p[35]}
N 32200 -1130 32200 -860 {lab=ctrl_p[35]}
N 31790 -1230 31790 -1130 {lab=ctrl_p[35]}
N 31790 -1130 32200 -1130 {lab=ctrl_p[35]}
N 31520 -1130 31520 -860 {lab=ctrl_p[35]}
N 31520 -860 31560 -860 {lab=ctrl_p[35]}
N 31970 -860 32020 -860 {lab=net1_35}
N 31730 -860 31770 -860 {lab=net1_35}
N 31600 -860 31640 -860 {lab=net2_35}
N 32250 -1000 33150 -1000 {lab=Vss}
N 32090 -860 32140 -860 {lab=net2_35}
N 31870 -950 31870 -930 {lab=net1_35}
N 31870 -930 32020 -930 {lab=net1_35}
N 31730 -930 31730 -860 {lab=net1_35}
N 32020 -930 32020 -860 {lab=net1_35}
N 31870 -1030 31870 -1010 {lab=1.2V}
N 31640 -860 31640 -810 {lab=net2_35}
N 31640 -810 31870 -810 {lab=net2_35}
N 31870 -810 31870 -780 {lab=net2_35}
N 31870 -720 31870 -700 {lab=Vss}
N 31870 -700 32250 -700 {lab=Vss}
N 32250 -1000 32250 -700 {lab=Vss}
N 31690 -670 31870 -670 {lab=Drain[35]}
N 31870 -810 32090 -810 {lab=net2_35}
N 32090 -860 32090 -810 {lab=net2_35}
N 31520 -1130 31790 -1130 {lab=ctrl_p[35]}
N 31830 -860 31930 -860 {lab=ctrl_n[35]}
N 31730 -930 31870 -930 {lab=net1_35}
N 31870 -1030 32770 -1030 {lab=1.2V}
N 31830 -1230 31830 -860 {lab=ctrl_n[35]}
N 31810 -860 31830 -860 {lab=ctrl_n[35]}
N 32500 -830 32670 -830 {lab=Drain[36]}
N 32670 -830 32670 -740 {lab=Drain[36]}
N 32590 -740 32670 -740 {lab=Drain[36]}
N 32500 -830 32500 -740 {lab=Drain[36]}
N 32590 -740 32590 -670 {lab=Drain[36]}
N 32500 -740 32590 -740 {lab=Drain[36]}
N 32770 -670 32960 -670 {lab=Drain[36]}
N 32770 -670 32770 -510 {lab=Drain[36]}
N 32870 -830 32870 -740 {lab=Drain[36]}
N 32960 -740 33040 -740 {lab=Drain[36]}
N 33040 -830 33040 -740 {lab=Drain[36]}
N 32960 -740 32960 -670 {lab=Drain[36]}
N 32870 -740 32960 -740 {lab=Drain[36]}
N 32500 -970 32500 -890 {lab=Dsense}
N 32590 -970 32670 -970 {lab=Dsense}
N 32670 -970 32670 -890 {lab=Dsense}
N 32870 -970 32870 -890 {lab=Dforce}
N 32960 -970 33040 -970 {lab=Dforce}
N 33040 -970 33040 -890 {lab=Dforce}
N 32590 -1090 33490 -1090 {lab=Dsense}
N 32590 -1090 32590 -970 {lab=Dsense}
N 32500 -970 32590 -970 {lab=Dsense}
N 32960 -1060 33860 -1060 {lab=Dforce}
N 32960 -1060 32960 -970 {lab=Dforce}
N 32870 -970 32960 -970 {lab=Dforce}
N 33080 -860 33100 -860 {lab=ctrl_p[36]}
N 33100 -1130 33100 -860 {lab=ctrl_p[36]}
N 32690 -1230 32690 -1130 {lab=ctrl_p[36]}
N 32690 -1130 33100 -1130 {lab=ctrl_p[36]}
N 32420 -1130 32420 -860 {lab=ctrl_p[36]}
N 32420 -860 32460 -860 {lab=ctrl_p[36]}
N 32870 -860 32920 -860 {lab=net1_36}
N 32630 -860 32670 -860 {lab=net1_36}
N 32500 -860 32540 -860 {lab=net2_36}
N 33150 -1000 34050 -1000 {lab=Vss}
N 32990 -860 33040 -860 {lab=net2_36}
N 32770 -950 32770 -930 {lab=net1_36}
N 32770 -930 32920 -930 {lab=net1_36}
N 32630 -930 32630 -860 {lab=net1_36}
N 32920 -930 32920 -860 {lab=net1_36}
N 32770 -1030 32770 -1010 {lab=1.2V}
N 32540 -860 32540 -810 {lab=net2_36}
N 32540 -810 32770 -810 {lab=net2_36}
N 32770 -810 32770 -780 {lab=net2_36}
N 32770 -720 32770 -700 {lab=Vss}
N 32770 -700 33150 -700 {lab=Vss}
N 33150 -1000 33150 -700 {lab=Vss}
N 32590 -670 32770 -670 {lab=Drain[36]}
N 32770 -810 32990 -810 {lab=net2_36}
N 32990 -860 32990 -810 {lab=net2_36}
N 32420 -1130 32690 -1130 {lab=ctrl_p[36]}
N 32730 -860 32830 -860 {lab=ctrl_n[36]}
N 32630 -930 32770 -930 {lab=net1_36}
N 32770 -1030 33670 -1030 {lab=1.2V}
N 32730 -1230 32730 -860 {lab=ctrl_n[36]}
N 32710 -860 32730 -860 {lab=ctrl_n[36]}
N 33400 -830 33570 -830 {lab=Drain[37]}
N 33570 -830 33570 -740 {lab=Drain[37]}
N 33490 -740 33570 -740 {lab=Drain[37]}
N 33400 -830 33400 -740 {lab=Drain[37]}
N 33490 -740 33490 -670 {lab=Drain[37]}
N 33400 -740 33490 -740 {lab=Drain[37]}
N 33670 -670 33860 -670 {lab=Drain[37]}
N 33670 -670 33670 -510 {lab=Drain[37]}
N 33770 -830 33770 -740 {lab=Drain[37]}
N 33860 -740 33940 -740 {lab=Drain[37]}
N 33940 -830 33940 -740 {lab=Drain[37]}
N 33860 -740 33860 -670 {lab=Drain[37]}
N 33770 -740 33860 -740 {lab=Drain[37]}
N 33400 -970 33400 -890 {lab=Dsense}
N 33490 -970 33570 -970 {lab=Dsense}
N 33570 -970 33570 -890 {lab=Dsense}
N 33770 -970 33770 -890 {lab=Dforce}
N 33860 -970 33940 -970 {lab=Dforce}
N 33940 -970 33940 -890 {lab=Dforce}
N 33490 -1090 34390 -1090 {lab=Dsense}
N 33490 -1090 33490 -970 {lab=Dsense}
N 33400 -970 33490 -970 {lab=Dsense}
N 33860 -1060 34760 -1060 {lab=Dforce}
N 33860 -1060 33860 -970 {lab=Dforce}
N 33770 -970 33860 -970 {lab=Dforce}
N 33980 -860 34000 -860 {lab=ctrl_p[37]}
N 34000 -1130 34000 -860 {lab=ctrl_p[37]}
N 33590 -1230 33590 -1130 {lab=ctrl_p[37]}
N 33590 -1130 34000 -1130 {lab=ctrl_p[37]}
N 33320 -1130 33320 -860 {lab=ctrl_p[37]}
N 33320 -860 33360 -860 {lab=ctrl_p[37]}
N 33770 -860 33820 -860 {lab=net1_37}
N 33530 -860 33570 -860 {lab=net1_37}
N 33400 -860 33440 -860 {lab=net2_37}
N 34050 -1000 34950 -1000 {lab=Vss}
N 33890 -860 33940 -860 {lab=net2_37}
N 33670 -950 33670 -930 {lab=net1_37}
N 33670 -930 33820 -930 {lab=net1_37}
N 33530 -930 33530 -860 {lab=net1_37}
N 33820 -930 33820 -860 {lab=net1_37}
N 33670 -1030 33670 -1010 {lab=1.2V}
N 33440 -860 33440 -810 {lab=net2_37}
N 33440 -810 33670 -810 {lab=net2_37}
N 33670 -810 33670 -780 {lab=net2_37}
N 33670 -720 33670 -700 {lab=Vss}
N 33670 -700 34050 -700 {lab=Vss}
N 34050 -1000 34050 -700 {lab=Vss}
N 33490 -670 33670 -670 {lab=Drain[37]}
N 33670 -810 33890 -810 {lab=net2_37}
N 33890 -860 33890 -810 {lab=net2_37}
N 33320 -1130 33590 -1130 {lab=ctrl_p[37]}
N 33630 -860 33730 -860 {lab=ctrl_n[37]}
N 33530 -930 33670 -930 {lab=net1_37}
N 33670 -1030 34570 -1030 {lab=1.2V}
N 33630 -1230 33630 -860 {lab=ctrl_n[37]}
N 33610 -860 33630 -860 {lab=ctrl_n[37]}
N 34300 -830 34470 -830 {lab=Drain[38]}
N 34470 -830 34470 -740 {lab=Drain[38]}
N 34390 -740 34470 -740 {lab=Drain[38]}
N 34300 -830 34300 -740 {lab=Drain[38]}
N 34390 -740 34390 -670 {lab=Drain[38]}
N 34300 -740 34390 -740 {lab=Drain[38]}
N 34570 -670 34760 -670 {lab=Drain[38]}
N 34570 -670 34570 -510 {lab=Drain[38]}
N 34670 -830 34670 -740 {lab=Drain[38]}
N 34760 -740 34840 -740 {lab=Drain[38]}
N 34840 -830 34840 -740 {lab=Drain[38]}
N 34760 -740 34760 -670 {lab=Drain[38]}
N 34670 -740 34760 -740 {lab=Drain[38]}
N 34300 -970 34300 -890 {lab=Dsense}
N 34390 -970 34470 -970 {lab=Dsense}
N 34470 -970 34470 -890 {lab=Dsense}
N 34670 -970 34670 -890 {lab=Dforce}
N 34760 -970 34840 -970 {lab=Dforce}
N 34840 -970 34840 -890 {lab=Dforce}
N 34390 -1090 35290 -1090 {lab=Dsense}
N 34390 -1090 34390 -970 {lab=Dsense}
N 34300 -970 34390 -970 {lab=Dsense}
N 34760 -1060 35660 -1060 {lab=Dforce}
N 34760 -1060 34760 -970 {lab=Dforce}
N 34670 -970 34760 -970 {lab=Dforce}
N 34880 -860 34900 -860 {lab=ctrl_p[38]}
N 34900 -1130 34900 -860 {lab=ctrl_p[38]}
N 34490 -1230 34490 -1130 {lab=ctrl_p[38]}
N 34490 -1130 34900 -1130 {lab=ctrl_p[38]}
N 34220 -1130 34220 -860 {lab=ctrl_p[38]}
N 34220 -860 34260 -860 {lab=ctrl_p[38]}
N 34670 -860 34720 -860 {lab=net1_38}
N 34430 -860 34470 -860 {lab=net1_38}
N 34300 -860 34340 -860 {lab=net2_38}
N 34950 -1000 35850 -1000 {lab=Vss}
N 34790 -860 34840 -860 {lab=net2_38}
N 34570 -950 34570 -930 {lab=net1_38}
N 34570 -930 34720 -930 {lab=net1_38}
N 34430 -930 34430 -860 {lab=net1_38}
N 34720 -930 34720 -860 {lab=net1_38}
N 34570 -1030 34570 -1010 {lab=1.2V}
N 34340 -860 34340 -810 {lab=net2_38}
N 34340 -810 34570 -810 {lab=net2_38}
N 34570 -810 34570 -780 {lab=net2_38}
N 34570 -720 34570 -700 {lab=Vss}
N 34570 -700 34950 -700 {lab=Vss}
N 34950 -1000 34950 -700 {lab=Vss}
N 34390 -670 34570 -670 {lab=Drain[38]}
N 34570 -810 34790 -810 {lab=net2_38}
N 34790 -860 34790 -810 {lab=net2_38}
N 34220 -1130 34490 -1130 {lab=ctrl_p[38]}
N 34530 -860 34630 -860 {lab=ctrl_n[38]}
N 34430 -930 34570 -930 {lab=net1_38}
N 34570 -1030 35470 -1030 {lab=1.2V}
N 34530 -1230 34530 -860 {lab=ctrl_n[38]}
N 34510 -860 34530 -860 {lab=ctrl_n[38]}
N 35200 -830 35370 -830 {lab=Drain[39]}
N 35370 -830 35370 -740 {lab=Drain[39]}
N 35290 -740 35370 -740 {lab=Drain[39]}
N 35200 -830 35200 -740 {lab=Drain[39]}
N 35290 -740 35290 -670 {lab=Drain[39]}
N 35200 -740 35290 -740 {lab=Drain[39]}
N 35470 -670 35660 -670 {lab=Drain[39]}
N 35470 -670 35470 -510 {lab=Drain[39]}
N 35570 -830 35570 -740 {lab=Drain[39]}
N 35660 -740 35740 -740 {lab=Drain[39]}
N 35740 -830 35740 -740 {lab=Drain[39]}
N 35660 -740 35660 -670 {lab=Drain[39]}
N 35570 -740 35660 -740 {lab=Drain[39]}
N 35200 -970 35200 -890 {lab=Dsense}
N 35290 -970 35370 -970 {lab=Dsense}
N 35370 -970 35370 -890 {lab=Dsense}
N 35570 -970 35570 -890 {lab=Dforce}
N 35660 -970 35740 -970 {lab=Dforce}
N 35740 -970 35740 -890 {lab=Dforce}
N 35290 -1090 36190 -1090 {lab=Dsense}
N 35290 -1090 35290 -970 {lab=Dsense}
N 35200 -970 35290 -970 {lab=Dsense}
N 35660 -1060 36560 -1060 {lab=Dforce}
N 35660 -1060 35660 -970 {lab=Dforce}
N 35570 -970 35660 -970 {lab=Dforce}
N 35780 -860 35800 -860 {lab=ctrl_p[39]}
N 35800 -1130 35800 -860 {lab=ctrl_p[39]}
N 35390 -1230 35390 -1130 {lab=ctrl_p[39]}
N 35390 -1130 35800 -1130 {lab=ctrl_p[39]}
N 35120 -1130 35120 -860 {lab=ctrl_p[39]}
N 35120 -860 35160 -860 {lab=ctrl_p[39]}
N 35570 -860 35620 -860 {lab=net1_39}
N 35330 -860 35370 -860 {lab=net1_39}
N 35200 -860 35240 -860 {lab=net2_39}
N 35850 -1000 36750 -1000 {lab=Vss}
N 35690 -860 35740 -860 {lab=net2_39}
N 35470 -950 35470 -930 {lab=net1_39}
N 35470 -930 35620 -930 {lab=net1_39}
N 35330 -930 35330 -860 {lab=net1_39}
N 35620 -930 35620 -860 {lab=net1_39}
N 35470 -1030 35470 -1010 {lab=1.2V}
N 35240 -860 35240 -810 {lab=net2_39}
N 35240 -810 35470 -810 {lab=net2_39}
N 35470 -810 35470 -780 {lab=net2_39}
N 35470 -720 35470 -700 {lab=Vss}
N 35470 -700 35850 -700 {lab=Vss}
N 35850 -1000 35850 -700 {lab=Vss}
N 35290 -670 35470 -670 {lab=Drain[39]}
N 35470 -810 35690 -810 {lab=net2_39}
N 35690 -860 35690 -810 {lab=net2_39}
N 35120 -1130 35390 -1130 {lab=ctrl_p[39]}
N 35430 -860 35530 -860 {lab=ctrl_n[39]}
N 35330 -930 35470 -930 {lab=net1_39}
N 35470 -1030 36370 -1030 {lab=1.2V}
N 35430 -1230 35430 -860 {lab=ctrl_n[39]}
N 35410 -860 35430 -860 {lab=ctrl_n[39]}
N 36100 -830 36270 -830 {lab=Drain[40]}
N 36270 -830 36270 -740 {lab=Drain[40]}
N 36190 -740 36270 -740 {lab=Drain[40]}
N 36100 -830 36100 -740 {lab=Drain[40]}
N 36190 -740 36190 -670 {lab=Drain[40]}
N 36100 -740 36190 -740 {lab=Drain[40]}
N 36370 -670 36560 -670 {lab=Drain[40]}
N 36370 -670 36370 -510 {lab=Drain[40]}
N 36470 -830 36470 -740 {lab=Drain[40]}
N 36560 -740 36640 -740 {lab=Drain[40]}
N 36640 -830 36640 -740 {lab=Drain[40]}
N 36560 -740 36560 -670 {lab=Drain[40]}
N 36470 -740 36560 -740 {lab=Drain[40]}
N 36100 -970 36100 -890 {lab=Dsense}
N 36190 -970 36270 -970 {lab=Dsense}
N 36270 -970 36270 -890 {lab=Dsense}
N 36470 -970 36470 -890 {lab=Dforce}
N 36560 -970 36640 -970 {lab=Dforce}
N 36640 -970 36640 -890 {lab=Dforce}
N 36190 -1090 37090 -1090 {lab=Dsense}
N 36190 -1090 36190 -970 {lab=Dsense}
N 36100 -970 36190 -970 {lab=Dsense}
N 36560 -1060 37460 -1060 {lab=Dforce}
N 36560 -1060 36560 -970 {lab=Dforce}
N 36470 -970 36560 -970 {lab=Dforce}
N 36680 -860 36700 -860 {lab=ctrl_p[40]}
N 36700 -1130 36700 -860 {lab=ctrl_p[40]}
N 36290 -1230 36290 -1130 {lab=ctrl_p[40]}
N 36290 -1130 36700 -1130 {lab=ctrl_p[40]}
N 36020 -1130 36020 -860 {lab=ctrl_p[40]}
N 36020 -860 36060 -860 {lab=ctrl_p[40]}
N 36470 -860 36520 -860 {lab=net1_40}
N 36230 -860 36270 -860 {lab=net1_40}
N 36100 -860 36140 -860 {lab=net2_40}
N 36750 -1000 37650 -1000 {lab=Vss}
N 36590 -860 36640 -860 {lab=net2_40}
N 36370 -950 36370 -930 {lab=net1_40}
N 36370 -930 36520 -930 {lab=net1_40}
N 36230 -930 36230 -860 {lab=net1_40}
N 36520 -930 36520 -860 {lab=net1_40}
N 36370 -1030 36370 -1010 {lab=1.2V}
N 36140 -860 36140 -810 {lab=net2_40}
N 36140 -810 36370 -810 {lab=net2_40}
N 36370 -810 36370 -780 {lab=net2_40}
N 36370 -720 36370 -700 {lab=Vss}
N 36370 -700 36750 -700 {lab=Vss}
N 36750 -1000 36750 -700 {lab=Vss}
N 36190 -670 36370 -670 {lab=Drain[40]}
N 36370 -810 36590 -810 {lab=net2_40}
N 36590 -860 36590 -810 {lab=net2_40}
N 36020 -1130 36290 -1130 {lab=ctrl_p[40]}
N 36330 -860 36430 -860 {lab=ctrl_n[40]}
N 36230 -930 36370 -930 {lab=net1_40}
N 36370 -1030 37270 -1030 {lab=1.2V}
N 36330 -1230 36330 -860 {lab=ctrl_n[40]}
N 36310 -860 36330 -860 {lab=ctrl_n[40]}
N 37000 -830 37170 -830 {lab=Drain[41]}
N 37170 -830 37170 -740 {lab=Drain[41]}
N 37090 -740 37170 -740 {lab=Drain[41]}
N 37000 -830 37000 -740 {lab=Drain[41]}
N 37090 -740 37090 -670 {lab=Drain[41]}
N 37000 -740 37090 -740 {lab=Drain[41]}
N 37270 -670 37460 -670 {lab=Drain[41]}
N 37270 -670 37270 -510 {lab=Drain[41]}
N 37370 -830 37370 -740 {lab=Drain[41]}
N 37460 -740 37540 -740 {lab=Drain[41]}
N 37540 -830 37540 -740 {lab=Drain[41]}
N 37460 -740 37460 -670 {lab=Drain[41]}
N 37370 -740 37460 -740 {lab=Drain[41]}
N 37000 -970 37000 -890 {lab=Dsense}
N 37090 -970 37170 -970 {lab=Dsense}
N 37170 -970 37170 -890 {lab=Dsense}
N 37370 -970 37370 -890 {lab=Dforce}
N 37460 -970 37540 -970 {lab=Dforce}
N 37540 -970 37540 -890 {lab=Dforce}
N 37090 -1090 37990 -1090 {lab=Dsense}
N 37090 -1090 37090 -970 {lab=Dsense}
N 37000 -970 37090 -970 {lab=Dsense}
N 37460 -1060 38360 -1060 {lab=Dforce}
N 37460 -1060 37460 -970 {lab=Dforce}
N 37370 -970 37460 -970 {lab=Dforce}
N 37580 -860 37600 -860 {lab=ctrl_p[41]}
N 37600 -1130 37600 -860 {lab=ctrl_p[41]}
N 37190 -1230 37190 -1130 {lab=ctrl_p[41]}
N 37190 -1130 37600 -1130 {lab=ctrl_p[41]}
N 36920 -1130 36920 -860 {lab=ctrl_p[41]}
N 36920 -860 36960 -860 {lab=ctrl_p[41]}
N 37370 -860 37420 -860 {lab=net1_41}
N 37130 -860 37170 -860 {lab=net1_41}
N 37000 -860 37040 -860 {lab=net2_41}
N 37650 -1000 38550 -1000 {lab=Vss}
N 37490 -860 37540 -860 {lab=net2_41}
N 37270 -950 37270 -930 {lab=net1_41}
N 37270 -930 37420 -930 {lab=net1_41}
N 37130 -930 37130 -860 {lab=net1_41}
N 37420 -930 37420 -860 {lab=net1_41}
N 37270 -1030 37270 -1010 {lab=1.2V}
N 37040 -860 37040 -810 {lab=net2_41}
N 37040 -810 37270 -810 {lab=net2_41}
N 37270 -810 37270 -780 {lab=net2_41}
N 37270 -720 37270 -700 {lab=Vss}
N 37270 -700 37650 -700 {lab=Vss}
N 37650 -1000 37650 -700 {lab=Vss}
N 37090 -670 37270 -670 {lab=Drain[41]}
N 37270 -810 37490 -810 {lab=net2_41}
N 37490 -860 37490 -810 {lab=net2_41}
N 36920 -1130 37190 -1130 {lab=ctrl_p[41]}
N 37230 -860 37330 -860 {lab=ctrl_n[41]}
N 37130 -930 37270 -930 {lab=net1_41}
N 37270 -1030 38170 -1030 {lab=1.2V}
N 37230 -1230 37230 -860 {lab=ctrl_n[41]}
N 37210 -860 37230 -860 {lab=ctrl_n[41]}
N 37900 -830 38070 -830 {lab=Drain[42]}
N 38070 -830 38070 -740 {lab=Drain[42]}
N 37990 -740 38070 -740 {lab=Drain[42]}
N 37900 -830 37900 -740 {lab=Drain[42]}
N 37990 -740 37990 -670 {lab=Drain[42]}
N 37900 -740 37990 -740 {lab=Drain[42]}
N 38170 -670 38360 -670 {lab=Drain[42]}
N 38170 -670 38170 -510 {lab=Drain[42]}
N 38270 -830 38270 -740 {lab=Drain[42]}
N 38360 -740 38440 -740 {lab=Drain[42]}
N 38440 -830 38440 -740 {lab=Drain[42]}
N 38360 -740 38360 -670 {lab=Drain[42]}
N 38270 -740 38360 -740 {lab=Drain[42]}
N 37900 -970 37900 -890 {lab=Dsense}
N 37990 -970 38070 -970 {lab=Dsense}
N 38070 -970 38070 -890 {lab=Dsense}
N 38270 -970 38270 -890 {lab=Dforce}
N 38360 -970 38440 -970 {lab=Dforce}
N 38440 -970 38440 -890 {lab=Dforce}
N 37990 -1090 38890 -1090 {lab=Dsense}
N 37990 -1090 37990 -970 {lab=Dsense}
N 37900 -970 37990 -970 {lab=Dsense}
N 38360 -1060 39260 -1060 {lab=Dforce}
N 38360 -1060 38360 -970 {lab=Dforce}
N 38270 -970 38360 -970 {lab=Dforce}
N 38480 -860 38500 -860 {lab=ctrl_p[42]}
N 38500 -1130 38500 -860 {lab=ctrl_p[42]}
N 38090 -1230 38090 -1130 {lab=ctrl_p[42]}
N 38090 -1130 38500 -1130 {lab=ctrl_p[42]}
N 37820 -1130 37820 -860 {lab=ctrl_p[42]}
N 37820 -860 37860 -860 {lab=ctrl_p[42]}
N 38270 -860 38320 -860 {lab=net1_42}
N 38030 -860 38070 -860 {lab=net1_42}
N 37900 -860 37940 -860 {lab=net2_42}
N 38550 -1000 39450 -1000 {lab=Vss}
N 38390 -860 38440 -860 {lab=net2_42}
N 38170 -950 38170 -930 {lab=net1_42}
N 38170 -930 38320 -930 {lab=net1_42}
N 38030 -930 38030 -860 {lab=net1_42}
N 38320 -930 38320 -860 {lab=net1_42}
N 38170 -1030 38170 -1010 {lab=1.2V}
N 37940 -860 37940 -810 {lab=net2_42}
N 37940 -810 38170 -810 {lab=net2_42}
N 38170 -810 38170 -780 {lab=net2_42}
N 38170 -720 38170 -700 {lab=Vss}
N 38170 -700 38550 -700 {lab=Vss}
N 38550 -1000 38550 -700 {lab=Vss}
N 37990 -670 38170 -670 {lab=Drain[42]}
N 38170 -810 38390 -810 {lab=net2_42}
N 38390 -860 38390 -810 {lab=net2_42}
N 37820 -1130 38090 -1130 {lab=ctrl_p[42]}
N 38130 -860 38230 -860 {lab=ctrl_n[42]}
N 38030 -930 38170 -930 {lab=net1_42}
N 38170 -1030 39070 -1030 {lab=1.2V}
N 38130 -1230 38130 -860 {lab=ctrl_n[42]}
N 38110 -860 38130 -860 {lab=ctrl_n[42]}
N 38800 -830 38970 -830 {lab=Drain[43]}
N 38970 -830 38970 -740 {lab=Drain[43]}
N 38890 -740 38970 -740 {lab=Drain[43]}
N 38800 -830 38800 -740 {lab=Drain[43]}
N 38890 -740 38890 -670 {lab=Drain[43]}
N 38800 -740 38890 -740 {lab=Drain[43]}
N 39070 -670 39260 -670 {lab=Drain[43]}
N 39070 -670 39070 -510 {lab=Drain[43]}
N 39170 -830 39170 -740 {lab=Drain[43]}
N 39260 -740 39340 -740 {lab=Drain[43]}
N 39340 -830 39340 -740 {lab=Drain[43]}
N 39260 -740 39260 -670 {lab=Drain[43]}
N 39170 -740 39260 -740 {lab=Drain[43]}
N 38800 -970 38800 -890 {lab=Dsense}
N 38890 -970 38970 -970 {lab=Dsense}
N 38970 -970 38970 -890 {lab=Dsense}
N 39170 -970 39170 -890 {lab=Dforce}
N 39260 -970 39340 -970 {lab=Dforce}
N 39340 -970 39340 -890 {lab=Dforce}
N 38890 -1090 39790 -1090 {lab=Dsense}
N 38890 -1090 38890 -970 {lab=Dsense}
N 38800 -970 38890 -970 {lab=Dsense}
N 39260 -1060 40160 -1060 {lab=Dforce}
N 39260 -1060 39260 -970 {lab=Dforce}
N 39170 -970 39260 -970 {lab=Dforce}
N 39380 -860 39400 -860 {lab=ctrl_p[43]}
N 39400 -1130 39400 -860 {lab=ctrl_p[43]}
N 38990 -1230 38990 -1130 {lab=ctrl_p[43]}
N 38990 -1130 39400 -1130 {lab=ctrl_p[43]}
N 38720 -1130 38720 -860 {lab=ctrl_p[43]}
N 38720 -860 38760 -860 {lab=ctrl_p[43]}
N 39170 -860 39220 -860 {lab=net1_43}
N 38930 -860 38970 -860 {lab=net1_43}
N 38800 -860 38840 -860 {lab=net2_43}
N 39450 -1000 40350 -1000 {lab=Vss}
N 39290 -860 39340 -860 {lab=net2_43}
N 39070 -950 39070 -930 {lab=net1_43}
N 39070 -930 39220 -930 {lab=net1_43}
N 38930 -930 38930 -860 {lab=net1_43}
N 39220 -930 39220 -860 {lab=net1_43}
N 39070 -1030 39070 -1010 {lab=1.2V}
N 38840 -860 38840 -810 {lab=net2_43}
N 38840 -810 39070 -810 {lab=net2_43}
N 39070 -810 39070 -780 {lab=net2_43}
N 39070 -720 39070 -700 {lab=Vss}
N 39070 -700 39450 -700 {lab=Vss}
N 39450 -1000 39450 -700 {lab=Vss}
N 38890 -670 39070 -670 {lab=Drain[43]}
N 39070 -810 39290 -810 {lab=net2_43}
N 39290 -860 39290 -810 {lab=net2_43}
N 38720 -1130 38990 -1130 {lab=ctrl_p[43]}
N 39030 -860 39130 -860 {lab=ctrl_n[43]}
N 38930 -930 39070 -930 {lab=net1_43}
N 39070 -1030 39970 -1030 {lab=1.2V}
N 39030 -1230 39030 -860 {lab=ctrl_n[43]}
N 39010 -860 39030 -860 {lab=ctrl_n[43]}
N 39700 -830 39870 -830 {lab=Drain[44]}
N 39870 -830 39870 -740 {lab=Drain[44]}
N 39790 -740 39870 -740 {lab=Drain[44]}
N 39700 -830 39700 -740 {lab=Drain[44]}
N 39790 -740 39790 -670 {lab=Drain[44]}
N 39700 -740 39790 -740 {lab=Drain[44]}
N 39970 -670 40160 -670 {lab=Drain[44]}
N 39970 -670 39970 -510 {lab=Drain[44]}
N 40070 -830 40070 -740 {lab=Drain[44]}
N 40160 -740 40240 -740 {lab=Drain[44]}
N 40240 -830 40240 -740 {lab=Drain[44]}
N 40160 -740 40160 -670 {lab=Drain[44]}
N 40070 -740 40160 -740 {lab=Drain[44]}
N 39700 -970 39700 -890 {lab=Dsense}
N 39790 -970 39870 -970 {lab=Dsense}
N 39870 -970 39870 -890 {lab=Dsense}
N 40070 -970 40070 -890 {lab=Dforce}
N 40160 -970 40240 -970 {lab=Dforce}
N 40240 -970 40240 -890 {lab=Dforce}
N 39790 -1090 40690 -1090 {lab=Dsense}
N 39790 -1090 39790 -970 {lab=Dsense}
N 39700 -970 39790 -970 {lab=Dsense}
N 40160 -1060 41060 -1060 {lab=Dforce}
N 40160 -1060 40160 -970 {lab=Dforce}
N 40070 -970 40160 -970 {lab=Dforce}
N 40280 -860 40300 -860 {lab=ctrl_p[44]}
N 40300 -1130 40300 -860 {lab=ctrl_p[44]}
N 39890 -1230 39890 -1130 {lab=ctrl_p[44]}
N 39890 -1130 40300 -1130 {lab=ctrl_p[44]}
N 39620 -1130 39620 -860 {lab=ctrl_p[44]}
N 39620 -860 39660 -860 {lab=ctrl_p[44]}
N 40070 -860 40120 -860 {lab=net1_44}
N 39830 -860 39870 -860 {lab=net1_44}
N 39700 -860 39740 -860 {lab=net2_44}
N 40350 -1000 41250 -1000 {lab=Vss}
N 40190 -860 40240 -860 {lab=net2_44}
N 39970 -950 39970 -930 {lab=net1_44}
N 39970 -930 40120 -930 {lab=net1_44}
N 39830 -930 39830 -860 {lab=net1_44}
N 40120 -930 40120 -860 {lab=net1_44}
N 39970 -1030 39970 -1010 {lab=1.2V}
N 39740 -860 39740 -810 {lab=net2_44}
N 39740 -810 39970 -810 {lab=net2_44}
N 39970 -810 39970 -780 {lab=net2_44}
N 39970 -720 39970 -700 {lab=Vss}
N 39970 -700 40350 -700 {lab=Vss}
N 40350 -1000 40350 -700 {lab=Vss}
N 39790 -670 39970 -670 {lab=Drain[44]}
N 39970 -810 40190 -810 {lab=net2_44}
N 40190 -860 40190 -810 {lab=net2_44}
N 39620 -1130 39890 -1130 {lab=ctrl_p[44]}
N 39930 -860 40030 -860 {lab=ctrl_n[44]}
N 39830 -930 39970 -930 {lab=net1_44}
N 39970 -1030 40870 -1030 {lab=1.2V}
N 39930 -1230 39930 -860 {lab=ctrl_n[44]}
N 39910 -860 39930 -860 {lab=ctrl_n[44]}
N 40600 -830 40770 -830 {lab=Drain[45]}
N 40770 -830 40770 -740 {lab=Drain[45]}
N 40690 -740 40770 -740 {lab=Drain[45]}
N 40600 -830 40600 -740 {lab=Drain[45]}
N 40690 -740 40690 -670 {lab=Drain[45]}
N 40600 -740 40690 -740 {lab=Drain[45]}
N 40870 -670 41060 -670 {lab=Drain[45]}
N 40870 -670 40870 -510 {lab=Drain[45]}
N 40970 -830 40970 -740 {lab=Drain[45]}
N 41060 -740 41140 -740 {lab=Drain[45]}
N 41140 -830 41140 -740 {lab=Drain[45]}
N 41060 -740 41060 -670 {lab=Drain[45]}
N 40970 -740 41060 -740 {lab=Drain[45]}
N 40600 -970 40600 -890 {lab=Dsense}
N 40690 -970 40770 -970 {lab=Dsense}
N 40770 -970 40770 -890 {lab=Dsense}
N 40970 -970 40970 -890 {lab=Dforce}
N 41060 -970 41140 -970 {lab=Dforce}
N 41140 -970 41140 -890 {lab=Dforce}
N 40690 -1090 41590 -1090 {lab=Dsense}
N 40690 -1090 40690 -970 {lab=Dsense}
N 40600 -970 40690 -970 {lab=Dsense}
N 41060 -1060 41960 -1060 {lab=Dforce}
N 41060 -1060 41060 -970 {lab=Dforce}
N 40970 -970 41060 -970 {lab=Dforce}
N 41180 -860 41200 -860 {lab=ctrl_p[45]}
N 41200 -1130 41200 -860 {lab=ctrl_p[45]}
N 40790 -1230 40790 -1130 {lab=ctrl_p[45]}
N 40790 -1130 41200 -1130 {lab=ctrl_p[45]}
N 40520 -1130 40520 -860 {lab=ctrl_p[45]}
N 40520 -860 40560 -860 {lab=ctrl_p[45]}
N 40970 -860 41020 -860 {lab=net1_45}
N 40730 -860 40770 -860 {lab=net1_45}
N 40600 -860 40640 -860 {lab=net2_45}
N 41250 -1000 42150 -1000 {lab=Vss}
N 41090 -860 41140 -860 {lab=net2_45}
N 40870 -950 40870 -930 {lab=net1_45}
N 40870 -930 41020 -930 {lab=net1_45}
N 40730 -930 40730 -860 {lab=net1_45}
N 41020 -930 41020 -860 {lab=net1_45}
N 40870 -1030 40870 -1010 {lab=1.2V}
N 40640 -860 40640 -810 {lab=net2_45}
N 40640 -810 40870 -810 {lab=net2_45}
N 40870 -810 40870 -780 {lab=net2_45}
N 40870 -720 40870 -700 {lab=Vss}
N 40870 -700 41250 -700 {lab=Vss}
N 41250 -1000 41250 -700 {lab=Vss}
N 40690 -670 40870 -670 {lab=Drain[45]}
N 40870 -810 41090 -810 {lab=net2_45}
N 41090 -860 41090 -810 {lab=net2_45}
N 40520 -1130 40790 -1130 {lab=ctrl_p[45]}
N 40830 -860 40930 -860 {lab=ctrl_n[45]}
N 40730 -930 40870 -930 {lab=net1_45}
N 40870 -1030 41770 -1030 {lab=1.2V}
N 40830 -1230 40830 -860 {lab=ctrl_n[45]}
N 40810 -860 40830 -860 {lab=ctrl_n[45]}
N 41500 -830 41670 -830 {lab=Drain[46]}
N 41670 -830 41670 -740 {lab=Drain[46]}
N 41590 -740 41670 -740 {lab=Drain[46]}
N 41500 -830 41500 -740 {lab=Drain[46]}
N 41590 -740 41590 -670 {lab=Drain[46]}
N 41500 -740 41590 -740 {lab=Drain[46]}
N 41770 -670 41960 -670 {lab=Drain[46]}
N 41770 -670 41770 -510 {lab=Drain[46]}
N 41870 -830 41870 -740 {lab=Drain[46]}
N 41960 -740 42040 -740 {lab=Drain[46]}
N 42040 -830 42040 -740 {lab=Drain[46]}
N 41960 -740 41960 -670 {lab=Drain[46]}
N 41870 -740 41960 -740 {lab=Drain[46]}
N 41500 -970 41500 -890 {lab=Dsense}
N 41590 -970 41670 -970 {lab=Dsense}
N 41670 -970 41670 -890 {lab=Dsense}
N 41870 -970 41870 -890 {lab=Dforce}
N 41960 -970 42040 -970 {lab=Dforce}
N 42040 -970 42040 -890 {lab=Dforce}
N 41590 -1090 42490 -1090 {lab=Dsense}
N 41590 -1090 41590 -970 {lab=Dsense}
N 41500 -970 41590 -970 {lab=Dsense}
N 41960 -1060 42860 -1060 {lab=Dforce}
N 41960 -1060 41960 -970 {lab=Dforce}
N 41870 -970 41960 -970 {lab=Dforce}
N 42080 -860 42100 -860 {lab=ctrl_p[46]}
N 42100 -1130 42100 -860 {lab=ctrl_p[46]}
N 41690 -1230 41690 -1130 {lab=ctrl_p[46]}
N 41690 -1130 42100 -1130 {lab=ctrl_p[46]}
N 41420 -1130 41420 -860 {lab=ctrl_p[46]}
N 41420 -860 41460 -860 {lab=ctrl_p[46]}
N 41870 -860 41920 -860 {lab=net1_46}
N 41630 -860 41670 -860 {lab=net1_46}
N 41500 -860 41540 -860 {lab=net2_46}
N 42150 -1000 43050 -1000 {lab=Vss}
N 41990 -860 42040 -860 {lab=net2_46}
N 41770 -950 41770 -930 {lab=net1_46}
N 41770 -930 41920 -930 {lab=net1_46}
N 41630 -930 41630 -860 {lab=net1_46}
N 41920 -930 41920 -860 {lab=net1_46}
N 41770 -1030 41770 -1010 {lab=1.2V}
N 41540 -860 41540 -810 {lab=net2_46}
N 41540 -810 41770 -810 {lab=net2_46}
N 41770 -810 41770 -780 {lab=net2_46}
N 41770 -720 41770 -700 {lab=Vss}
N 41770 -700 42150 -700 {lab=Vss}
N 42150 -1000 42150 -700 {lab=Vss}
N 41590 -670 41770 -670 {lab=Drain[46]}
N 41770 -810 41990 -810 {lab=net2_46}
N 41990 -860 41990 -810 {lab=net2_46}
N 41420 -1130 41690 -1130 {lab=ctrl_p[46]}
N 41730 -860 41830 -860 {lab=ctrl_n[46]}
N 41630 -930 41770 -930 {lab=net1_46}
N 41770 -1030 42670 -1030 {lab=1.2V}
N 41730 -1230 41730 -860 {lab=ctrl_n[46]}
N 41710 -860 41730 -860 {lab=ctrl_n[46]}
N 42400 -830 42570 -830 {lab=Drain[47]}
N 42570 -830 42570 -740 {lab=Drain[47]}
N 42490 -740 42570 -740 {lab=Drain[47]}
N 42400 -830 42400 -740 {lab=Drain[47]}
N 42490 -740 42490 -670 {lab=Drain[47]}
N 42400 -740 42490 -740 {lab=Drain[47]}
N 42670 -670 42860 -670 {lab=Drain[47]}
N 42670 -670 42670 -510 {lab=Drain[47]}
N 42770 -830 42770 -740 {lab=Drain[47]}
N 42860 -740 42940 -740 {lab=Drain[47]}
N 42940 -830 42940 -740 {lab=Drain[47]}
N 42860 -740 42860 -670 {lab=Drain[47]}
N 42770 -740 42860 -740 {lab=Drain[47]}
N 42400 -970 42400 -890 {lab=Dsense}
N 42490 -970 42570 -970 {lab=Dsense}
N 42570 -970 42570 -890 {lab=Dsense}
N 42770 -970 42770 -890 {lab=Dforce}
N 42860 -970 42940 -970 {lab=Dforce}
N 42940 -970 42940 -890 {lab=Dforce}
N 42490 -1090 43390 -1090 {lab=Dsense}
N 42490 -1090 42490 -970 {lab=Dsense}
N 42400 -970 42490 -970 {lab=Dsense}
N 42860 -1060 43760 -1060 {lab=Dforce}
N 42860 -1060 42860 -970 {lab=Dforce}
N 42770 -970 42860 -970 {lab=Dforce}
N 42980 -860 43000 -860 {lab=ctrl_p[47]}
N 43000 -1130 43000 -860 {lab=ctrl_p[47]}
N 42590 -1230 42590 -1130 {lab=ctrl_p[47]}
N 42590 -1130 43000 -1130 {lab=ctrl_p[47]}
N 42320 -1130 42320 -860 {lab=ctrl_p[47]}
N 42320 -860 42360 -860 {lab=ctrl_p[47]}
N 42770 -860 42820 -860 {lab=net1_47}
N 42530 -860 42570 -860 {lab=net1_47}
N 42400 -860 42440 -860 {lab=net2_47}
N 43050 -1000 43950 -1000 {lab=Vss}
N 42890 -860 42940 -860 {lab=net2_47}
N 42670 -950 42670 -930 {lab=net1_47}
N 42670 -930 42820 -930 {lab=net1_47}
N 42530 -930 42530 -860 {lab=net1_47}
N 42820 -930 42820 -860 {lab=net1_47}
N 42670 -1030 42670 -1010 {lab=1.2V}
N 42440 -860 42440 -810 {lab=net2_47}
N 42440 -810 42670 -810 {lab=net2_47}
N 42670 -810 42670 -780 {lab=net2_47}
N 42670 -720 42670 -700 {lab=Vss}
N 42670 -700 43050 -700 {lab=Vss}
N 43050 -1000 43050 -700 {lab=Vss}
N 42490 -670 42670 -670 {lab=Drain[47]}
N 42670 -810 42890 -810 {lab=net2_47}
N 42890 -860 42890 -810 {lab=net2_47}
N 42320 -1130 42590 -1130 {lab=ctrl_p[47]}
N 42630 -860 42730 -860 {lab=ctrl_n[47]}
N 42530 -930 42670 -930 {lab=net1_47}
N 42670 -1030 43570 -1030 {lab=1.2V}
N 42630 -1230 42630 -860 {lab=ctrl_n[47]}
N 42610 -860 42630 -860 {lab=ctrl_n[47]}
N 43300 -830 43470 -830 {lab=Drain[48]}
N 43470 -830 43470 -740 {lab=Drain[48]}
N 43390 -740 43470 -740 {lab=Drain[48]}
N 43300 -830 43300 -740 {lab=Drain[48]}
N 43390 -740 43390 -670 {lab=Drain[48]}
N 43300 -740 43390 -740 {lab=Drain[48]}
N 43570 -670 43760 -670 {lab=Drain[48]}
N 43570 -670 43570 -510 {lab=Drain[48]}
N 43670 -830 43670 -740 {lab=Drain[48]}
N 43760 -740 43840 -740 {lab=Drain[48]}
N 43840 -830 43840 -740 {lab=Drain[48]}
N 43760 -740 43760 -670 {lab=Drain[48]}
N 43670 -740 43760 -740 {lab=Drain[48]}
N 43300 -970 43300 -890 {lab=Dsense}
N 43390 -970 43470 -970 {lab=Dsense}
N 43470 -970 43470 -890 {lab=Dsense}
N 43670 -970 43670 -890 {lab=Dforce}
N 43760 -970 43840 -970 {lab=Dforce}
N 43840 -970 43840 -890 {lab=Dforce}
N 43390 -1090 44290 -1090 {lab=Dsense}
N 43390 -1090 43390 -970 {lab=Dsense}
N 43300 -970 43390 -970 {lab=Dsense}
N 43760 -1060 44660 -1060 {lab=Dforce}
N 43760 -1060 43760 -970 {lab=Dforce}
N 43670 -970 43760 -970 {lab=Dforce}
N 43880 -860 43900 -860 {lab=ctrl_p[48]}
N 43900 -1130 43900 -860 {lab=ctrl_p[48]}
N 43490 -1230 43490 -1130 {lab=ctrl_p[48]}
N 43490 -1130 43900 -1130 {lab=ctrl_p[48]}
N 43220 -1130 43220 -860 {lab=ctrl_p[48]}
N 43220 -860 43260 -860 {lab=ctrl_p[48]}
N 43670 -860 43720 -860 {lab=net1_48}
N 43430 -860 43470 -860 {lab=net1_48}
N 43300 -860 43340 -860 {lab=net2_48}
N 43950 -1000 44850 -1000 {lab=Vss}
N 43790 -860 43840 -860 {lab=net2_48}
N 43570 -950 43570 -930 {lab=net1_48}
N 43570 -930 43720 -930 {lab=net1_48}
N 43430 -930 43430 -860 {lab=net1_48}
N 43720 -930 43720 -860 {lab=net1_48}
N 43570 -1030 43570 -1010 {lab=1.2V}
N 43340 -860 43340 -810 {lab=net2_48}
N 43340 -810 43570 -810 {lab=net2_48}
N 43570 -810 43570 -780 {lab=net2_48}
N 43570 -720 43570 -700 {lab=Vss}
N 43570 -700 43950 -700 {lab=Vss}
N 43950 -1000 43950 -700 {lab=Vss}
N 43390 -670 43570 -670 {lab=Drain[48]}
N 43570 -810 43790 -810 {lab=net2_48}
N 43790 -860 43790 -810 {lab=net2_48}
N 43220 -1130 43490 -1130 {lab=ctrl_p[48]}
N 43530 -860 43630 -860 {lab=ctrl_n[48]}
N 43430 -930 43570 -930 {lab=net1_48}
N 43570 -1030 44470 -1030 {lab=1.2V}
N 43530 -1230 43530 -860 {lab=ctrl_n[48]}
N 43510 -860 43530 -860 {lab=ctrl_n[48]}
N 44200 -830 44370 -830 {lab=Drain[49]}
N 44370 -830 44370 -740 {lab=Drain[49]}
N 44290 -740 44370 -740 {lab=Drain[49]}
N 44200 -830 44200 -740 {lab=Drain[49]}
N 44290 -740 44290 -670 {lab=Drain[49]}
N 44200 -740 44290 -740 {lab=Drain[49]}
N 44470 -670 44660 -670 {lab=Drain[49]}
N 44470 -670 44470 -510 {lab=Drain[49]}
N 44570 -830 44570 -740 {lab=Drain[49]}
N 44660 -740 44740 -740 {lab=Drain[49]}
N 44740 -830 44740 -740 {lab=Drain[49]}
N 44660 -740 44660 -670 {lab=Drain[49]}
N 44570 -740 44660 -740 {lab=Drain[49]}
N 44200 -970 44200 -890 {lab=Dsense}
N 44290 -970 44370 -970 {lab=Dsense}
N 44370 -970 44370 -890 {lab=Dsense}
N 44570 -970 44570 -890 {lab=Dforce}
N 44660 -970 44740 -970 {lab=Dforce}
N 44740 -970 44740 -890 {lab=Dforce}
N 44290 -1090 45190 -1090 {lab=Dsense}
N 44290 -1090 44290 -970 {lab=Dsense}
N 44200 -970 44290 -970 {lab=Dsense}
N 44660 -1060 45560 -1060 {lab=Dforce}
N 44660 -1060 44660 -970 {lab=Dforce}
N 44570 -970 44660 -970 {lab=Dforce}
N 44780 -860 44800 -860 {lab=ctrl_p[49]}
N 44800 -1130 44800 -860 {lab=ctrl_p[49]}
N 44390 -1230 44390 -1130 {lab=ctrl_p[49]}
N 44390 -1130 44800 -1130 {lab=ctrl_p[49]}
N 44120 -1130 44120 -860 {lab=ctrl_p[49]}
N 44120 -860 44160 -860 {lab=ctrl_p[49]}
N 44570 -860 44620 -860 {lab=net1_49}
N 44330 -860 44370 -860 {lab=net1_49}
N 44200 -860 44240 -860 {lab=net2_49}
N 44850 -1000 45750 -1000 {lab=Vss}
N 44690 -860 44740 -860 {lab=net2_49}
N 44470 -950 44470 -930 {lab=net1_49}
N 44470 -930 44620 -930 {lab=net1_49}
N 44330 -930 44330 -860 {lab=net1_49}
N 44620 -930 44620 -860 {lab=net1_49}
N 44470 -1030 44470 -1010 {lab=1.2V}
N 44240 -860 44240 -810 {lab=net2_49}
N 44240 -810 44470 -810 {lab=net2_49}
N 44470 -810 44470 -780 {lab=net2_49}
N 44470 -720 44470 -700 {lab=Vss}
N 44470 -700 44850 -700 {lab=Vss}
N 44850 -1000 44850 -700 {lab=Vss}
N 44290 -670 44470 -670 {lab=Drain[49]}
N 44470 -810 44690 -810 {lab=net2_49}
N 44690 -860 44690 -810 {lab=net2_49}
N 44120 -1130 44390 -1130 {lab=ctrl_p[49]}
N 44430 -860 44530 -860 {lab=ctrl_n[49]}
N 44330 -930 44470 -930 {lab=net1_49}
N 44470 -1030 45370 -1030 {lab=1.2V}
N 44430 -1230 44430 -860 {lab=ctrl_n[49]}
N 44410 -860 44430 -860 {lab=ctrl_n[49]}
N 45100 -830 45270 -830 {lab=Drain[50]}
N 45270 -830 45270 -740 {lab=Drain[50]}
N 45190 -740 45270 -740 {lab=Drain[50]}
N 45100 -830 45100 -740 {lab=Drain[50]}
N 45190 -740 45190 -670 {lab=Drain[50]}
N 45100 -740 45190 -740 {lab=Drain[50]}
N 45370 -670 45560 -670 {lab=Drain[50]}
N 45370 -670 45370 -510 {lab=Drain[50]}
N 45470 -830 45470 -740 {lab=Drain[50]}
N 45560 -740 45640 -740 {lab=Drain[50]}
N 45640 -830 45640 -740 {lab=Drain[50]}
N 45560 -740 45560 -670 {lab=Drain[50]}
N 45470 -740 45560 -740 {lab=Drain[50]}
N 45100 -970 45100 -890 {lab=Dsense}
N 45190 -970 45270 -970 {lab=Dsense}
N 45270 -970 45270 -890 {lab=Dsense}
N 45470 -970 45470 -890 {lab=Dforce}
N 45560 -970 45640 -970 {lab=Dforce}
N 45640 -970 45640 -890 {lab=Dforce}
N 45190 -1090 46090 -1090 {lab=Dsense}
N 45190 -1090 45190 -970 {lab=Dsense}
N 45100 -970 45190 -970 {lab=Dsense}
N 45560 -1060 46460 -1060 {lab=Dforce}
N 45560 -1060 45560 -970 {lab=Dforce}
N 45470 -970 45560 -970 {lab=Dforce}
N 45680 -860 45700 -860 {lab=ctrl_p[50]}
N 45700 -1130 45700 -860 {lab=ctrl_p[50]}
N 45290 -1230 45290 -1130 {lab=ctrl_p[50]}
N 45290 -1130 45700 -1130 {lab=ctrl_p[50]}
N 45020 -1130 45020 -860 {lab=ctrl_p[50]}
N 45020 -860 45060 -860 {lab=ctrl_p[50]}
N 45470 -860 45520 -860 {lab=net1_50}
N 45230 -860 45270 -860 {lab=net1_50}
N 45100 -860 45140 -860 {lab=net2_50}
N 45750 -1000 46650 -1000 {lab=Vss}
N 45590 -860 45640 -860 {lab=net2_50}
N 45370 -950 45370 -930 {lab=net1_50}
N 45370 -930 45520 -930 {lab=net1_50}
N 45230 -930 45230 -860 {lab=net1_50}
N 45520 -930 45520 -860 {lab=net1_50}
N 45370 -1030 45370 -1010 {lab=1.2V}
N 45140 -860 45140 -810 {lab=net2_50}
N 45140 -810 45370 -810 {lab=net2_50}
N 45370 -810 45370 -780 {lab=net2_50}
N 45370 -720 45370 -700 {lab=Vss}
N 45370 -700 45750 -700 {lab=Vss}
N 45750 -1000 45750 -700 {lab=Vss}
N 45190 -670 45370 -670 {lab=Drain[50]}
N 45370 -810 45590 -810 {lab=net2_50}
N 45590 -860 45590 -810 {lab=net2_50}
N 45020 -1130 45290 -1130 {lab=ctrl_p[50]}
N 45330 -860 45430 -860 {lab=ctrl_n[50]}
N 45230 -930 45370 -930 {lab=net1_50}
N 45370 -1030 46270 -1030 {lab=1.2V}
N 45330 -1230 45330 -860 {lab=ctrl_n[50]}
N 45310 -860 45330 -860 {lab=ctrl_n[50]}
N 46000 -830 46170 -830 {lab=Drain[51]}
N 46170 -830 46170 -740 {lab=Drain[51]}
N 46090 -740 46170 -740 {lab=Drain[51]}
N 46000 -830 46000 -740 {lab=Drain[51]}
N 46090 -740 46090 -670 {lab=Drain[51]}
N 46000 -740 46090 -740 {lab=Drain[51]}
N 46270 -670 46460 -670 {lab=Drain[51]}
N 46270 -670 46270 -510 {lab=Drain[51]}
N 46370 -830 46370 -740 {lab=Drain[51]}
N 46460 -740 46540 -740 {lab=Drain[51]}
N 46540 -830 46540 -740 {lab=Drain[51]}
N 46460 -740 46460 -670 {lab=Drain[51]}
N 46370 -740 46460 -740 {lab=Drain[51]}
N 46000 -970 46000 -890 {lab=Dsense}
N 46090 -970 46170 -970 {lab=Dsense}
N 46170 -970 46170 -890 {lab=Dsense}
N 46370 -970 46370 -890 {lab=Dforce}
N 46460 -970 46540 -970 {lab=Dforce}
N 46540 -970 46540 -890 {lab=Dforce}
N 46090 -1090 46990 -1090 {lab=Dsense}
N 46090 -1090 46090 -970 {lab=Dsense}
N 46000 -970 46090 -970 {lab=Dsense}
N 46460 -1060 47360 -1060 {lab=Dforce}
N 46460 -1060 46460 -970 {lab=Dforce}
N 46370 -970 46460 -970 {lab=Dforce}
N 46580 -860 46600 -860 {lab=ctrl_p[51]}
N 46600 -1130 46600 -860 {lab=ctrl_p[51]}
N 46190 -1230 46190 -1130 {lab=ctrl_p[51]}
N 46190 -1130 46600 -1130 {lab=ctrl_p[51]}
N 45920 -1130 45920 -860 {lab=ctrl_p[51]}
N 45920 -860 45960 -860 {lab=ctrl_p[51]}
N 46370 -860 46420 -860 {lab=net1_51}
N 46130 -860 46170 -860 {lab=net1_51}
N 46000 -860 46040 -860 {lab=net2_51}
N 46650 -1000 47550 -1000 {lab=Vss}
N 46490 -860 46540 -860 {lab=net2_51}
N 46270 -950 46270 -930 {lab=net1_51}
N 46270 -930 46420 -930 {lab=net1_51}
N 46130 -930 46130 -860 {lab=net1_51}
N 46420 -930 46420 -860 {lab=net1_51}
N 46270 -1030 46270 -1010 {lab=1.2V}
N 46040 -860 46040 -810 {lab=net2_51}
N 46040 -810 46270 -810 {lab=net2_51}
N 46270 -810 46270 -780 {lab=net2_51}
N 46270 -720 46270 -700 {lab=Vss}
N 46270 -700 46650 -700 {lab=Vss}
N 46650 -1000 46650 -700 {lab=Vss}
N 46090 -670 46270 -670 {lab=Drain[51]}
N 46270 -810 46490 -810 {lab=net2_51}
N 46490 -860 46490 -810 {lab=net2_51}
N 45920 -1130 46190 -1130 {lab=ctrl_p[51]}
N 46230 -860 46330 -860 {lab=ctrl_n[51]}
N 46130 -930 46270 -930 {lab=net1_51}
N 46270 -1030 47170 -1030 {lab=1.2V}
N 46230 -1230 46230 -860 {lab=ctrl_n[51]}
N 46210 -860 46230 -860 {lab=ctrl_n[51]}
N 46900 -830 47070 -830 {lab=Drain[52]}
N 47070 -830 47070 -740 {lab=Drain[52]}
N 46990 -740 47070 -740 {lab=Drain[52]}
N 46900 -830 46900 -740 {lab=Drain[52]}
N 46990 -740 46990 -670 {lab=Drain[52]}
N 46900 -740 46990 -740 {lab=Drain[52]}
N 47170 -670 47360 -670 {lab=Drain[52]}
N 47170 -670 47170 -510 {lab=Drain[52]}
N 47270 -830 47270 -740 {lab=Drain[52]}
N 47360 -740 47440 -740 {lab=Drain[52]}
N 47440 -830 47440 -740 {lab=Drain[52]}
N 47360 -740 47360 -670 {lab=Drain[52]}
N 47270 -740 47360 -740 {lab=Drain[52]}
N 46900 -970 46900 -890 {lab=Dsense}
N 46990 -970 47070 -970 {lab=Dsense}
N 47070 -970 47070 -890 {lab=Dsense}
N 47270 -970 47270 -890 {lab=Dforce}
N 47360 -970 47440 -970 {lab=Dforce}
N 47440 -970 47440 -890 {lab=Dforce}
N 46990 -1090 47890 -1090 {lab=Dsense}
N 46990 -1090 46990 -970 {lab=Dsense}
N 46900 -970 46990 -970 {lab=Dsense}
N 47360 -1060 48260 -1060 {lab=Dforce}
N 47360 -1060 47360 -970 {lab=Dforce}
N 47270 -970 47360 -970 {lab=Dforce}
N 47480 -860 47500 -860 {lab=ctrl_p[52]}
N 47500 -1130 47500 -860 {lab=ctrl_p[52]}
N 47090 -1230 47090 -1130 {lab=ctrl_p[52]}
N 47090 -1130 47500 -1130 {lab=ctrl_p[52]}
N 46820 -1130 46820 -860 {lab=ctrl_p[52]}
N 46820 -860 46860 -860 {lab=ctrl_p[52]}
N 47270 -860 47320 -860 {lab=net1_52}
N 47030 -860 47070 -860 {lab=net1_52}
N 46900 -860 46940 -860 {lab=net2_52}
N 47550 -1000 48450 -1000 {lab=Vss}
N 47390 -860 47440 -860 {lab=net2_52}
N 47170 -950 47170 -930 {lab=net1_52}
N 47170 -930 47320 -930 {lab=net1_52}
N 47030 -930 47030 -860 {lab=net1_52}
N 47320 -930 47320 -860 {lab=net1_52}
N 47170 -1030 47170 -1010 {lab=1.2V}
N 46940 -860 46940 -810 {lab=net2_52}
N 46940 -810 47170 -810 {lab=net2_52}
N 47170 -810 47170 -780 {lab=net2_52}
N 47170 -720 47170 -700 {lab=Vss}
N 47170 -700 47550 -700 {lab=Vss}
N 47550 -1000 47550 -700 {lab=Vss}
N 46990 -670 47170 -670 {lab=Drain[52]}
N 47170 -810 47390 -810 {lab=net2_52}
N 47390 -860 47390 -810 {lab=net2_52}
N 46820 -1130 47090 -1130 {lab=ctrl_p[52]}
N 47130 -860 47230 -860 {lab=ctrl_n[52]}
N 47030 -930 47170 -930 {lab=net1_52}
N 47170 -1030 48070 -1030 {lab=1.2V}
N 47130 -1230 47130 -860 {lab=ctrl_n[52]}
N 47110 -860 47130 -860 {lab=ctrl_n[52]}
N 47800 -830 47970 -830 {lab=Drain[53]}
N 47970 -830 47970 -740 {lab=Drain[53]}
N 47890 -740 47970 -740 {lab=Drain[53]}
N 47800 -830 47800 -740 {lab=Drain[53]}
N 47890 -740 47890 -670 {lab=Drain[53]}
N 47800 -740 47890 -740 {lab=Drain[53]}
N 48070 -670 48260 -670 {lab=Drain[53]}
N 48070 -670 48070 -510 {lab=Drain[53]}
N 48170 -830 48170 -740 {lab=Drain[53]}
N 48260 -740 48340 -740 {lab=Drain[53]}
N 48340 -830 48340 -740 {lab=Drain[53]}
N 48260 -740 48260 -670 {lab=Drain[53]}
N 48170 -740 48260 -740 {lab=Drain[53]}
N 47800 -970 47800 -890 {lab=Dsense}
N 47890 -970 47970 -970 {lab=Dsense}
N 47970 -970 47970 -890 {lab=Dsense}
N 48170 -970 48170 -890 {lab=Dforce}
N 48260 -970 48340 -970 {lab=Dforce}
N 48340 -970 48340 -890 {lab=Dforce}
N 47890 -1090 48790 -1090 {lab=Dsense}
N 47890 -1090 47890 -970 {lab=Dsense}
N 47800 -970 47890 -970 {lab=Dsense}
N 48260 -1060 49160 -1060 {lab=Dforce}
N 48260 -1060 48260 -970 {lab=Dforce}
N 48170 -970 48260 -970 {lab=Dforce}
N 48380 -860 48400 -860 {lab=ctrl_p[53]}
N 48400 -1130 48400 -860 {lab=ctrl_p[53]}
N 47990 -1230 47990 -1130 {lab=ctrl_p[53]}
N 47990 -1130 48400 -1130 {lab=ctrl_p[53]}
N 47720 -1130 47720 -860 {lab=ctrl_p[53]}
N 47720 -860 47760 -860 {lab=ctrl_p[53]}
N 48170 -860 48220 -860 {lab=net1_53}
N 47930 -860 47970 -860 {lab=net1_53}
N 47800 -860 47840 -860 {lab=net2_53}
N 48450 -1000 49350 -1000 {lab=Vss}
N 48290 -860 48340 -860 {lab=net2_53}
N 48070 -950 48070 -930 {lab=net1_53}
N 48070 -930 48220 -930 {lab=net1_53}
N 47930 -930 47930 -860 {lab=net1_53}
N 48220 -930 48220 -860 {lab=net1_53}
N 48070 -1030 48070 -1010 {lab=1.2V}
N 47840 -860 47840 -810 {lab=net2_53}
N 47840 -810 48070 -810 {lab=net2_53}
N 48070 -810 48070 -780 {lab=net2_53}
N 48070 -720 48070 -700 {lab=Vss}
N 48070 -700 48450 -700 {lab=Vss}
N 48450 -1000 48450 -700 {lab=Vss}
N 47890 -670 48070 -670 {lab=Drain[53]}
N 48070 -810 48290 -810 {lab=net2_53}
N 48290 -860 48290 -810 {lab=net2_53}
N 47720 -1130 47990 -1130 {lab=ctrl_p[53]}
N 48030 -860 48130 -860 {lab=ctrl_n[53]}
N 47930 -930 48070 -930 {lab=net1_53}
N 48070 -1030 48970 -1030 {lab=1.2V}
N 48030 -1230 48030 -860 {lab=ctrl_n[53]}
N 48010 -860 48030 -860 {lab=ctrl_n[53]}
N 48700 -830 48870 -830 {lab=Drain[54]}
N 48870 -830 48870 -740 {lab=Drain[54]}
N 48790 -740 48870 -740 {lab=Drain[54]}
N 48700 -830 48700 -740 {lab=Drain[54]}
N 48790 -740 48790 -670 {lab=Drain[54]}
N 48700 -740 48790 -740 {lab=Drain[54]}
N 48970 -670 49160 -670 {lab=Drain[54]}
N 48970 -670 48970 -510 {lab=Drain[54]}
N 49070 -830 49070 -740 {lab=Drain[54]}
N 49160 -740 49240 -740 {lab=Drain[54]}
N 49240 -830 49240 -740 {lab=Drain[54]}
N 49160 -740 49160 -670 {lab=Drain[54]}
N 49070 -740 49160 -740 {lab=Drain[54]}
N 48700 -970 48700 -890 {lab=Dsense}
N 48790 -970 48870 -970 {lab=Dsense}
N 48870 -970 48870 -890 {lab=Dsense}
N 49070 -970 49070 -890 {lab=Dforce}
N 49160 -970 49240 -970 {lab=Dforce}
N 49240 -970 49240 -890 {lab=Dforce}
N 48790 -1090 49690 -1090 {lab=Dsense}
N 48790 -1090 48790 -970 {lab=Dsense}
N 48700 -970 48790 -970 {lab=Dsense}
N 49160 -1060 50060 -1060 {lab=Dforce}
N 49160 -1060 49160 -970 {lab=Dforce}
N 49070 -970 49160 -970 {lab=Dforce}
N 49280 -860 49300 -860 {lab=ctrl_p[54]}
N 49300 -1130 49300 -860 {lab=ctrl_p[54]}
N 48890 -1230 48890 -1130 {lab=ctrl_p[54]}
N 48890 -1130 49300 -1130 {lab=ctrl_p[54]}
N 48620 -1130 48620 -860 {lab=ctrl_p[54]}
N 48620 -860 48660 -860 {lab=ctrl_p[54]}
N 49070 -860 49120 -860 {lab=net1_54}
N 48830 -860 48870 -860 {lab=net1_54}
N 48700 -860 48740 -860 {lab=net2_54}
N 49350 -1000 50250 -1000 {lab=Vss}
N 49190 -860 49240 -860 {lab=net2_54}
N 48970 -950 48970 -930 {lab=net1_54}
N 48970 -930 49120 -930 {lab=net1_54}
N 48830 -930 48830 -860 {lab=net1_54}
N 49120 -930 49120 -860 {lab=net1_54}
N 48970 -1030 48970 -1010 {lab=1.2V}
N 48740 -860 48740 -810 {lab=net2_54}
N 48740 -810 48970 -810 {lab=net2_54}
N 48970 -810 48970 -780 {lab=net2_54}
N 48970 -720 48970 -700 {lab=Vss}
N 48970 -700 49350 -700 {lab=Vss}
N 49350 -1000 49350 -700 {lab=Vss}
N 48790 -670 48970 -670 {lab=Drain[54]}
N 48970 -810 49190 -810 {lab=net2_54}
N 49190 -860 49190 -810 {lab=net2_54}
N 48620 -1130 48890 -1130 {lab=ctrl_p[54]}
N 48930 -860 49030 -860 {lab=ctrl_n[54]}
N 48830 -930 48970 -930 {lab=net1_54}
N 48970 -1030 49870 -1030 {lab=1.2V}
N 48930 -1230 48930 -860 {lab=ctrl_n[54]}
N 48910 -860 48930 -860 {lab=ctrl_n[54]}
N 49600 -830 49770 -830 {lab=Drain[55]}
N 49770 -830 49770 -740 {lab=Drain[55]}
N 49690 -740 49770 -740 {lab=Drain[55]}
N 49600 -830 49600 -740 {lab=Drain[55]}
N 49690 -740 49690 -670 {lab=Drain[55]}
N 49600 -740 49690 -740 {lab=Drain[55]}
N 49870 -670 50060 -670 {lab=Drain[55]}
N 49870 -670 49870 -510 {lab=Drain[55]}
N 49970 -830 49970 -740 {lab=Drain[55]}
N 50060 -740 50140 -740 {lab=Drain[55]}
N 50140 -830 50140 -740 {lab=Drain[55]}
N 50060 -740 50060 -670 {lab=Drain[55]}
N 49970 -740 50060 -740 {lab=Drain[55]}
N 49600 -970 49600 -890 {lab=Dsense}
N 49690 -970 49770 -970 {lab=Dsense}
N 49770 -970 49770 -890 {lab=Dsense}
N 49970 -970 49970 -890 {lab=Dforce}
N 50060 -970 50140 -970 {lab=Dforce}
N 50140 -970 50140 -890 {lab=Dforce}
N 49690 -1090 50590 -1090 {lab=Dsense}
N 49690 -1090 49690 -970 {lab=Dsense}
N 49600 -970 49690 -970 {lab=Dsense}
N 50060 -1060 50960 -1060 {lab=Dforce}
N 50060 -1060 50060 -970 {lab=Dforce}
N 49970 -970 50060 -970 {lab=Dforce}
N 50180 -860 50200 -860 {lab=ctrl_p[55]}
N 50200 -1130 50200 -860 {lab=ctrl_p[55]}
N 49790 -1230 49790 -1130 {lab=ctrl_p[55]}
N 49790 -1130 50200 -1130 {lab=ctrl_p[55]}
N 49520 -1130 49520 -860 {lab=ctrl_p[55]}
N 49520 -860 49560 -860 {lab=ctrl_p[55]}
N 49970 -860 50020 -860 {lab=net1_55}
N 49730 -860 49770 -860 {lab=net1_55}
N 49600 -860 49640 -860 {lab=net2_55}
N 50250 -1000 51150 -1000 {lab=Vss}
N 50090 -860 50140 -860 {lab=net2_55}
N 49870 -950 49870 -930 {lab=net1_55}
N 49870 -930 50020 -930 {lab=net1_55}
N 49730 -930 49730 -860 {lab=net1_55}
N 50020 -930 50020 -860 {lab=net1_55}
N 49870 -1030 49870 -1010 {lab=1.2V}
N 49640 -860 49640 -810 {lab=net2_55}
N 49640 -810 49870 -810 {lab=net2_55}
N 49870 -810 49870 -780 {lab=net2_55}
N 49870 -720 49870 -700 {lab=Vss}
N 49870 -700 50250 -700 {lab=Vss}
N 50250 -1000 50250 -700 {lab=Vss}
N 49690 -670 49870 -670 {lab=Drain[55]}
N 49870 -810 50090 -810 {lab=net2_55}
N 50090 -860 50090 -810 {lab=net2_55}
N 49520 -1130 49790 -1130 {lab=ctrl_p[55]}
N 49830 -860 49930 -860 {lab=ctrl_n[55]}
N 49730 -930 49870 -930 {lab=net1_55}
N 49870 -1030 50770 -1030 {lab=1.2V}
N 49830 -1230 49830 -860 {lab=ctrl_n[55]}
N 49810 -860 49830 -860 {lab=ctrl_n[55]}
N 50500 -830 50670 -830 {lab=Drain[56]}
N 50670 -830 50670 -740 {lab=Drain[56]}
N 50590 -740 50670 -740 {lab=Drain[56]}
N 50500 -830 50500 -740 {lab=Drain[56]}
N 50590 -740 50590 -670 {lab=Drain[56]}
N 50500 -740 50590 -740 {lab=Drain[56]}
N 50770 -670 50960 -670 {lab=Drain[56]}
N 50770 -670 50770 -510 {lab=Drain[56]}
N 50870 -830 50870 -740 {lab=Drain[56]}
N 50960 -740 51040 -740 {lab=Drain[56]}
N 51040 -830 51040 -740 {lab=Drain[56]}
N 50960 -740 50960 -670 {lab=Drain[56]}
N 50870 -740 50960 -740 {lab=Drain[56]}
N 50500 -970 50500 -890 {lab=Dsense}
N 50590 -970 50670 -970 {lab=Dsense}
N 50670 -970 50670 -890 {lab=Dsense}
N 50870 -970 50870 -890 {lab=Dforce}
N 50960 -970 51040 -970 {lab=Dforce}
N 51040 -970 51040 -890 {lab=Dforce}
N 50590 -1090 51490 -1090 {lab=Dsense}
N 50590 -1090 50590 -970 {lab=Dsense}
N 50500 -970 50590 -970 {lab=Dsense}
N 50960 -1060 51860 -1060 {lab=Dforce}
N 50960 -1060 50960 -970 {lab=Dforce}
N 50870 -970 50960 -970 {lab=Dforce}
N 51080 -860 51100 -860 {lab=ctrl_p[56]}
N 51100 -1130 51100 -860 {lab=ctrl_p[56]}
N 50690 -1230 50690 -1130 {lab=ctrl_p[56]}
N 50690 -1130 51100 -1130 {lab=ctrl_p[56]}
N 50420 -1130 50420 -860 {lab=ctrl_p[56]}
N 50420 -860 50460 -860 {lab=ctrl_p[56]}
N 50870 -860 50920 -860 {lab=net1_56}
N 50630 -860 50670 -860 {lab=net1_56}
N 50500 -860 50540 -860 {lab=net2_56}
N 51150 -1000 52050 -1000 {lab=Vss}
N 50990 -860 51040 -860 {lab=net2_56}
N 50770 -950 50770 -930 {lab=net1_56}
N 50770 -930 50920 -930 {lab=net1_56}
N 50630 -930 50630 -860 {lab=net1_56}
N 50920 -930 50920 -860 {lab=net1_56}
N 50770 -1030 50770 -1010 {lab=1.2V}
N 50540 -860 50540 -810 {lab=net2_56}
N 50540 -810 50770 -810 {lab=net2_56}
N 50770 -810 50770 -780 {lab=net2_56}
N 50770 -720 50770 -700 {lab=Vss}
N 50770 -700 51150 -700 {lab=Vss}
N 51150 -1000 51150 -700 {lab=Vss}
N 50590 -670 50770 -670 {lab=Drain[56]}
N 50770 -810 50990 -810 {lab=net2_56}
N 50990 -860 50990 -810 {lab=net2_56}
N 50420 -1130 50690 -1130 {lab=ctrl_p[56]}
N 50730 -860 50830 -860 {lab=ctrl_n[56]}
N 50630 -930 50770 -930 {lab=net1_56}
N 50770 -1030 51670 -1030 {lab=1.2V}
N 50730 -1230 50730 -860 {lab=ctrl_n[56]}
N 50710 -860 50730 -860 {lab=ctrl_n[56]}
N 51400 -830 51570 -830 {lab=Drain[57]}
N 51570 -830 51570 -740 {lab=Drain[57]}
N 51490 -740 51570 -740 {lab=Drain[57]}
N 51400 -830 51400 -740 {lab=Drain[57]}
N 51490 -740 51490 -670 {lab=Drain[57]}
N 51400 -740 51490 -740 {lab=Drain[57]}
N 51670 -670 51860 -670 {lab=Drain[57]}
N 51670 -670 51670 -510 {lab=Drain[57]}
N 51770 -830 51770 -740 {lab=Drain[57]}
N 51860 -740 51940 -740 {lab=Drain[57]}
N 51940 -830 51940 -740 {lab=Drain[57]}
N 51860 -740 51860 -670 {lab=Drain[57]}
N 51770 -740 51860 -740 {lab=Drain[57]}
N 51400 -970 51400 -890 {lab=Dsense}
N 51490 -970 51570 -970 {lab=Dsense}
N 51570 -970 51570 -890 {lab=Dsense}
N 51770 -970 51770 -890 {lab=Dforce}
N 51860 -970 51940 -970 {lab=Dforce}
N 51940 -970 51940 -890 {lab=Dforce}
N 51490 -1090 52390 -1090 {lab=Dsense}
N 51490 -1090 51490 -970 {lab=Dsense}
N 51400 -970 51490 -970 {lab=Dsense}
N 51860 -1060 52760 -1060 {lab=Dforce}
N 51860 -1060 51860 -970 {lab=Dforce}
N 51770 -970 51860 -970 {lab=Dforce}
N 51980 -860 52000 -860 {lab=ctrl_p[57]}
N 52000 -1130 52000 -860 {lab=ctrl_p[57]}
N 51590 -1230 51590 -1130 {lab=ctrl_p[57]}
N 51590 -1130 52000 -1130 {lab=ctrl_p[57]}
N 51320 -1130 51320 -860 {lab=ctrl_p[57]}
N 51320 -860 51360 -860 {lab=ctrl_p[57]}
N 51770 -860 51820 -860 {lab=net1_57}
N 51530 -860 51570 -860 {lab=net1_57}
N 51400 -860 51440 -860 {lab=net2_57}
N 52050 -1000 52950 -1000 {lab=Vss}
N 51890 -860 51940 -860 {lab=net2_57}
N 51670 -950 51670 -930 {lab=net1_57}
N 51670 -930 51820 -930 {lab=net1_57}
N 51530 -930 51530 -860 {lab=net1_57}
N 51820 -930 51820 -860 {lab=net1_57}
N 51670 -1030 51670 -1010 {lab=1.2V}
N 51440 -860 51440 -810 {lab=net2_57}
N 51440 -810 51670 -810 {lab=net2_57}
N 51670 -810 51670 -780 {lab=net2_57}
N 51670 -720 51670 -700 {lab=Vss}
N 51670 -700 52050 -700 {lab=Vss}
N 52050 -1000 52050 -700 {lab=Vss}
N 51490 -670 51670 -670 {lab=Drain[57]}
N 51670 -810 51890 -810 {lab=net2_57}
N 51890 -860 51890 -810 {lab=net2_57}
N 51320 -1130 51590 -1130 {lab=ctrl_p[57]}
N 51630 -860 51730 -860 {lab=ctrl_n[57]}
N 51530 -930 51670 -930 {lab=net1_57}
N 51670 -1030 52570 -1030 {lab=1.2V}
N 51630 -1230 51630 -860 {lab=ctrl_n[57]}
N 51610 -860 51630 -860 {lab=ctrl_n[57]}
N 52300 -830 52470 -830 {lab=Drain[58]}
N 52470 -830 52470 -740 {lab=Drain[58]}
N 52390 -740 52470 -740 {lab=Drain[58]}
N 52300 -830 52300 -740 {lab=Drain[58]}
N 52390 -740 52390 -670 {lab=Drain[58]}
N 52300 -740 52390 -740 {lab=Drain[58]}
N 52570 -670 52760 -670 {lab=Drain[58]}
N 52570 -670 52570 -510 {lab=Drain[58]}
N 52670 -830 52670 -740 {lab=Drain[58]}
N 52760 -740 52840 -740 {lab=Drain[58]}
N 52840 -830 52840 -740 {lab=Drain[58]}
N 52760 -740 52760 -670 {lab=Drain[58]}
N 52670 -740 52760 -740 {lab=Drain[58]}
N 52300 -970 52300 -890 {lab=Dsense}
N 52390 -970 52470 -970 {lab=Dsense}
N 52470 -970 52470 -890 {lab=Dsense}
N 52670 -970 52670 -890 {lab=Dforce}
N 52760 -970 52840 -970 {lab=Dforce}
N 52840 -970 52840 -890 {lab=Dforce}
N 52390 -1090 53290 -1090 {lab=Dsense}
N 52390 -1090 52390 -970 {lab=Dsense}
N 52300 -970 52390 -970 {lab=Dsense}
N 52760 -1060 53660 -1060 {lab=Dforce}
N 52760 -1060 52760 -970 {lab=Dforce}
N 52670 -970 52760 -970 {lab=Dforce}
N 52880 -860 52900 -860 {lab=ctrl_p[58]}
N 52900 -1130 52900 -860 {lab=ctrl_p[58]}
N 52490 -1230 52490 -1130 {lab=ctrl_p[58]}
N 52490 -1130 52900 -1130 {lab=ctrl_p[58]}
N 52220 -1130 52220 -860 {lab=ctrl_p[58]}
N 52220 -860 52260 -860 {lab=ctrl_p[58]}
N 52670 -860 52720 -860 {lab=net1_58}
N 52430 -860 52470 -860 {lab=net1_58}
N 52300 -860 52340 -860 {lab=net2_58}
N 52950 -1000 53850 -1000 {lab=Vss}
N 52790 -860 52840 -860 {lab=net2_58}
N 52570 -950 52570 -930 {lab=net1_58}
N 52570 -930 52720 -930 {lab=net1_58}
N 52430 -930 52430 -860 {lab=net1_58}
N 52720 -930 52720 -860 {lab=net1_58}
N 52570 -1030 52570 -1010 {lab=1.2V}
N 52340 -860 52340 -810 {lab=net2_58}
N 52340 -810 52570 -810 {lab=net2_58}
N 52570 -810 52570 -780 {lab=net2_58}
N 52570 -720 52570 -700 {lab=Vss}
N 52570 -700 52950 -700 {lab=Vss}
N 52950 -1000 52950 -700 {lab=Vss}
N 52390 -670 52570 -670 {lab=Drain[58]}
N 52570 -810 52790 -810 {lab=net2_58}
N 52790 -860 52790 -810 {lab=net2_58}
N 52220 -1130 52490 -1130 {lab=ctrl_p[58]}
N 52530 -860 52630 -860 {lab=ctrl_n[58]}
N 52430 -930 52570 -930 {lab=net1_58}
N 52570 -1030 53470 -1030 {lab=1.2V}
N 52530 -1230 52530 -860 {lab=ctrl_n[58]}
N 52510 -860 52530 -860 {lab=ctrl_n[58]}
N 53200 -830 53370 -830 {lab=Drain[59]}
N 53370 -830 53370 -740 {lab=Drain[59]}
N 53290 -740 53370 -740 {lab=Drain[59]}
N 53200 -830 53200 -740 {lab=Drain[59]}
N 53290 -740 53290 -670 {lab=Drain[59]}
N 53200 -740 53290 -740 {lab=Drain[59]}
N 53470 -670 53660 -670 {lab=Drain[59]}
N 53470 -670 53470 -510 {lab=Drain[59]}
N 53570 -830 53570 -740 {lab=Drain[59]}
N 53660 -740 53740 -740 {lab=Drain[59]}
N 53740 -830 53740 -740 {lab=Drain[59]}
N 53660 -740 53660 -670 {lab=Drain[59]}
N 53570 -740 53660 -740 {lab=Drain[59]}
N 53200 -970 53200 -890 {lab=Dsense}
N 53290 -970 53370 -970 {lab=Dsense}
N 53370 -970 53370 -890 {lab=Dsense}
N 53570 -970 53570 -890 {lab=Dforce}
N 53660 -970 53740 -970 {lab=Dforce}
N 53740 -970 53740 -890 {lab=Dforce}
N 53290 -1090 54190 -1090 {lab=Dsense}
N 53290 -1090 53290 -970 {lab=Dsense}
N 53200 -970 53290 -970 {lab=Dsense}
N 53660 -1060 54560 -1060 {lab=Dforce}
N 53660 -1060 53660 -970 {lab=Dforce}
N 53570 -970 53660 -970 {lab=Dforce}
N 53780 -860 53800 -860 {lab=ctrl_p[59]}
N 53800 -1130 53800 -860 {lab=ctrl_p[59]}
N 53390 -1230 53390 -1130 {lab=ctrl_p[59]}
N 53390 -1130 53800 -1130 {lab=ctrl_p[59]}
N 53120 -1130 53120 -860 {lab=ctrl_p[59]}
N 53120 -860 53160 -860 {lab=ctrl_p[59]}
N 53570 -860 53620 -860 {lab=net1_59}
N 53330 -860 53370 -860 {lab=net1_59}
N 53200 -860 53240 -860 {lab=net2_59}
N 53850 -1000 54750 -1000 {lab=Vss}
N 53690 -860 53740 -860 {lab=net2_59}
N 53470 -950 53470 -930 {lab=net1_59}
N 53470 -930 53620 -930 {lab=net1_59}
N 53330 -930 53330 -860 {lab=net1_59}
N 53620 -930 53620 -860 {lab=net1_59}
N 53470 -1030 53470 -1010 {lab=1.2V}
N 53240 -860 53240 -810 {lab=net2_59}
N 53240 -810 53470 -810 {lab=net2_59}
N 53470 -810 53470 -780 {lab=net2_59}
N 53470 -720 53470 -700 {lab=Vss}
N 53470 -700 53850 -700 {lab=Vss}
N 53850 -1000 53850 -700 {lab=Vss}
N 53290 -670 53470 -670 {lab=Drain[59]}
N 53470 -810 53690 -810 {lab=net2_59}
N 53690 -860 53690 -810 {lab=net2_59}
N 53120 -1130 53390 -1130 {lab=ctrl_p[59]}
N 53430 -860 53530 -860 {lab=ctrl_n[59]}
N 53330 -930 53470 -930 {lab=net1_59}
N 53470 -1030 54370 -1030 {lab=1.2V}
N 53430 -1230 53430 -860 {lab=ctrl_n[59]}
N 53410 -860 53430 -860 {lab=ctrl_n[59]}
N 54100 -830 54270 -830 {lab=Drain[60]}
N 54270 -830 54270 -740 {lab=Drain[60]}
N 54190 -740 54270 -740 {lab=Drain[60]}
N 54100 -830 54100 -740 {lab=Drain[60]}
N 54190 -740 54190 -670 {lab=Drain[60]}
N 54100 -740 54190 -740 {lab=Drain[60]}
N 54370 -670 54560 -670 {lab=Drain[60]}
N 54370 -670 54370 -510 {lab=Drain[60]}
N 54470 -830 54470 -740 {lab=Drain[60]}
N 54560 -740 54640 -740 {lab=Drain[60]}
N 54640 -830 54640 -740 {lab=Drain[60]}
N 54560 -740 54560 -670 {lab=Drain[60]}
N 54470 -740 54560 -740 {lab=Drain[60]}
N 54100 -970 54100 -890 {lab=Dsense}
N 54190 -970 54270 -970 {lab=Dsense}
N 54270 -970 54270 -890 {lab=Dsense}
N 54470 -970 54470 -890 {lab=Dforce}
N 54560 -970 54640 -970 {lab=Dforce}
N 54640 -970 54640 -890 {lab=Dforce}
N 54190 -1090 55090 -1090 {lab=Dsense}
N 54190 -1090 54190 -970 {lab=Dsense}
N 54100 -970 54190 -970 {lab=Dsense}
N 54560 -1060 55460 -1060 {lab=Dforce}
N 54560 -1060 54560 -970 {lab=Dforce}
N 54470 -970 54560 -970 {lab=Dforce}
N 54680 -860 54700 -860 {lab=ctrl_p[60]}
N 54700 -1130 54700 -860 {lab=ctrl_p[60]}
N 54290 -1230 54290 -1130 {lab=ctrl_p[60]}
N 54290 -1130 54700 -1130 {lab=ctrl_p[60]}
N 54020 -1130 54020 -860 {lab=ctrl_p[60]}
N 54020 -860 54060 -860 {lab=ctrl_p[60]}
N 54470 -860 54520 -860 {lab=net1_60}
N 54230 -860 54270 -860 {lab=net1_60}
N 54100 -860 54140 -860 {lab=net2_60}
N 54750 -1000 55650 -1000 {lab=Vss}
N 54590 -860 54640 -860 {lab=net2_60}
N 54370 -950 54370 -930 {lab=net1_60}
N 54370 -930 54520 -930 {lab=net1_60}
N 54230 -930 54230 -860 {lab=net1_60}
N 54520 -930 54520 -860 {lab=net1_60}
N 54370 -1030 54370 -1010 {lab=1.2V}
N 54140 -860 54140 -810 {lab=net2_60}
N 54140 -810 54370 -810 {lab=net2_60}
N 54370 -810 54370 -780 {lab=net2_60}
N 54370 -720 54370 -700 {lab=Vss}
N 54370 -700 54750 -700 {lab=Vss}
N 54750 -1000 54750 -700 {lab=Vss}
N 54190 -670 54370 -670 {lab=Drain[60]}
N 54370 -810 54590 -810 {lab=net2_60}
N 54590 -860 54590 -810 {lab=net2_60}
N 54020 -1130 54290 -1130 {lab=ctrl_p[60]}
N 54330 -860 54430 -860 {lab=ctrl_n[60]}
N 54230 -930 54370 -930 {lab=net1_60}
N 54370 -1030 55270 -1030 {lab=1.2V}
N 54330 -1230 54330 -860 {lab=ctrl_n[60]}
N 54310 -860 54330 -860 {lab=ctrl_n[60]}
N 55000 -830 55170 -830 {lab=Drain[61]}
N 55170 -830 55170 -740 {lab=Drain[61]}
N 55090 -740 55170 -740 {lab=Drain[61]}
N 55000 -830 55000 -740 {lab=Drain[61]}
N 55090 -740 55090 -670 {lab=Drain[61]}
N 55000 -740 55090 -740 {lab=Drain[61]}
N 55270 -670 55460 -670 {lab=Drain[61]}
N 55270 -670 55270 -510 {lab=Drain[61]}
N 55370 -830 55370 -740 {lab=Drain[61]}
N 55460 -740 55540 -740 {lab=Drain[61]}
N 55540 -830 55540 -740 {lab=Drain[61]}
N 55460 -740 55460 -670 {lab=Drain[61]}
N 55370 -740 55460 -740 {lab=Drain[61]}
N 55000 -970 55000 -890 {lab=Dsense}
N 55090 -970 55170 -970 {lab=Dsense}
N 55170 -970 55170 -890 {lab=Dsense}
N 55370 -970 55370 -890 {lab=Dforce}
N 55460 -970 55540 -970 {lab=Dforce}
N 55540 -970 55540 -890 {lab=Dforce}
N 55090 -1090 55990 -1090 {lab=Dsense}
N 55090 -1090 55090 -970 {lab=Dsense}
N 55000 -970 55090 -970 {lab=Dsense}
N 55460 -1060 56360 -1060 {lab=Dforce}
N 55460 -1060 55460 -970 {lab=Dforce}
N 55370 -970 55460 -970 {lab=Dforce}
N 55580 -860 55600 -860 {lab=ctrl_p[61]}
N 55600 -1130 55600 -860 {lab=ctrl_p[61]}
N 55190 -1230 55190 -1130 {lab=ctrl_p[61]}
N 55190 -1130 55600 -1130 {lab=ctrl_p[61]}
N 54920 -1130 54920 -860 {lab=ctrl_p[61]}
N 54920 -860 54960 -860 {lab=ctrl_p[61]}
N 55370 -860 55420 -860 {lab=net1_61}
N 55130 -860 55170 -860 {lab=net1_61}
N 55000 -860 55040 -860 {lab=net2_61}
N 55650 -1000 56550 -1000 {lab=Vss}
N 55490 -860 55540 -860 {lab=net2_61}
N 55270 -950 55270 -930 {lab=net1_61}
N 55270 -930 55420 -930 {lab=net1_61}
N 55130 -930 55130 -860 {lab=net1_61}
N 55420 -930 55420 -860 {lab=net1_61}
N 55270 -1030 55270 -1010 {lab=1.2V}
N 55040 -860 55040 -810 {lab=net2_61}
N 55040 -810 55270 -810 {lab=net2_61}
N 55270 -810 55270 -780 {lab=net2_61}
N 55270 -720 55270 -700 {lab=Vss}
N 55270 -700 55650 -700 {lab=Vss}
N 55650 -1000 55650 -700 {lab=Vss}
N 55090 -670 55270 -670 {lab=Drain[61]}
N 55270 -810 55490 -810 {lab=net2_61}
N 55490 -860 55490 -810 {lab=net2_61}
N 54920 -1130 55190 -1130 {lab=ctrl_p[61]}
N 55230 -860 55330 -860 {lab=ctrl_n[61]}
N 55130 -930 55270 -930 {lab=net1_61}
N 55270 -1030 56170 -1030 {lab=1.2V}
N 55230 -1230 55230 -860 {lab=ctrl_n[61]}
N 55210 -860 55230 -860 {lab=ctrl_n[61]}
N 55900 -830 56070 -830 {lab=Drain[62]}
N 56070 -830 56070 -740 {lab=Drain[62]}
N 55990 -740 56070 -740 {lab=Drain[62]}
N 55900 -830 55900 -740 {lab=Drain[62]}
N 55990 -740 55990 -670 {lab=Drain[62]}
N 55900 -740 55990 -740 {lab=Drain[62]}
N 56170 -670 56360 -670 {lab=Drain[62]}
N 56170 -670 56170 -510 {lab=Drain[62]}
N 56270 -830 56270 -740 {lab=Drain[62]}
N 56360 -740 56440 -740 {lab=Drain[62]}
N 56440 -830 56440 -740 {lab=Drain[62]}
N 56360 -740 56360 -670 {lab=Drain[62]}
N 56270 -740 56360 -740 {lab=Drain[62]}
N 55900 -970 55900 -890 {lab=Dsense}
N 55990 -970 56070 -970 {lab=Dsense}
N 56070 -970 56070 -890 {lab=Dsense}
N 56270 -970 56270 -890 {lab=Dforce}
N 56360 -970 56440 -970 {lab=Dforce}
N 56440 -970 56440 -890 {lab=Dforce}
N 55990 -1090 56890 -1090 {lab=Dsense}
N 55990 -1090 55990 -970 {lab=Dsense}
N 55900 -970 55990 -970 {lab=Dsense}
N 56360 -1060 57260 -1060 {lab=Dforce}
N 56360 -1060 56360 -970 {lab=Dforce}
N 56270 -970 56360 -970 {lab=Dforce}
N 56480 -860 56500 -860 {lab=ctrl_p[62]}
N 56500 -1130 56500 -860 {lab=ctrl_p[62]}
N 56090 -1230 56090 -1130 {lab=ctrl_p[62]}
N 56090 -1130 56500 -1130 {lab=ctrl_p[62]}
N 55820 -1130 55820 -860 {lab=ctrl_p[62]}
N 55820 -860 55860 -860 {lab=ctrl_p[62]}
N 56270 -860 56320 -860 {lab=net1_62}
N 56030 -860 56070 -860 {lab=net1_62}
N 55900 -860 55940 -860 {lab=net2_62}
N 56550 -1000 57450 -1000 {lab=Vss}
N 56390 -860 56440 -860 {lab=net2_62}
N 56170 -950 56170 -930 {lab=net1_62}
N 56170 -930 56320 -930 {lab=net1_62}
N 56030 -930 56030 -860 {lab=net1_62}
N 56320 -930 56320 -860 {lab=net1_62}
N 56170 -1030 56170 -1010 {lab=1.2V}
N 55940 -860 55940 -810 {lab=net2_62}
N 55940 -810 56170 -810 {lab=net2_62}
N 56170 -810 56170 -780 {lab=net2_62}
N 56170 -720 56170 -700 {lab=Vss}
N 56170 -700 56550 -700 {lab=Vss}
N 56550 -1000 56550 -700 {lab=Vss}
N 55990 -670 56170 -670 {lab=Drain[62]}
N 56170 -810 56390 -810 {lab=net2_62}
N 56390 -860 56390 -810 {lab=net2_62}
N 55820 -1130 56090 -1130 {lab=ctrl_p[62]}
N 56130 -860 56230 -860 {lab=ctrl_n[62]}
N 56030 -930 56170 -930 {lab=net1_62}
N 56170 -1030 57070 -1030 {lab=1.2V}
N 56130 -1230 56130 -860 {lab=ctrl_n[62]}
N 56110 -860 56130 -860 {lab=ctrl_n[62]}
N 56800 -830 56970 -830 {lab=Drain[63]}
N 56970 -830 56970 -740 {lab=Drain[63]}
N 56890 -740 56970 -740 {lab=Drain[63]}
N 56800 -830 56800 -740 {lab=Drain[63]}
N 56890 -740 56890 -670 {lab=Drain[63]}
N 56800 -740 56890 -740 {lab=Drain[63]}
N 57070 -670 57260 -670 {lab=Drain[63]}
N 57070 -670 57070 -510 {lab=Drain[63]}
N 57170 -830 57170 -740 {lab=Drain[63]}
N 57260 -740 57340 -740 {lab=Drain[63]}
N 57340 -830 57340 -740 {lab=Drain[63]}
N 57260 -740 57260 -670 {lab=Drain[63]}
N 57170 -740 57260 -740 {lab=Drain[63]}
N 56800 -970 56800 -890 {lab=Dsense}
N 56890 -970 56970 -970 {lab=Dsense}
N 56970 -970 56970 -890 {lab=Dsense}
N 57170 -970 57170 -890 {lab=Dforce}
N 57260 -970 57340 -970 {lab=Dforce}
N 57340 -970 57340 -890 {lab=Dforce}
N 56890 -1090 57790 -1090 {lab=Dsense}
N 56890 -1090 56890 -970 {lab=Dsense}
N 56800 -970 56890 -970 {lab=Dsense}
N 57260 -1060 58160 -1060 {lab=Dforce}
N 57260 -1060 57260 -970 {lab=Dforce}
N 57170 -970 57260 -970 {lab=Dforce}
N 57380 -860 57400 -860 {lab=ctrl_p[63]}
N 57400 -1130 57400 -860 {lab=ctrl_p[63]}
N 56990 -1230 56990 -1130 {lab=ctrl_p[63]}
N 56990 -1130 57400 -1130 {lab=ctrl_p[63]}
N 56720 -1130 56720 -860 {lab=ctrl_p[63]}
N 56720 -860 56760 -860 {lab=ctrl_p[63]}
N 57170 -860 57220 -860 {lab=net1_63}
N 56930 -860 56970 -860 {lab=net1_63}
N 56800 -860 56840 -860 {lab=net2_63}
N 57450 -1000 58350 -1000 {lab=Vss}
N 57290 -860 57340 -860 {lab=net2_63}
N 57070 -950 57070 -930 {lab=net1_63}
N 57070 -930 57220 -930 {lab=net1_63}
N 56930 -930 56930 -860 {lab=net1_63}
N 57220 -930 57220 -860 {lab=net1_63}
N 57070 -1030 57070 -1010 {lab=1.2V}
N 56840 -860 56840 -810 {lab=net2_63}
N 56840 -810 57070 -810 {lab=net2_63}
N 57070 -810 57070 -780 {lab=net2_63}
N 57070 -720 57070 -700 {lab=Vss}
N 57070 -700 57450 -700 {lab=Vss}
N 57450 -1000 57450 -700 {lab=Vss}
N 56890 -670 57070 -670 {lab=Drain[63]}
N 57070 -810 57290 -810 {lab=net2_63}
N 57290 -860 57290 -810 {lab=net2_63}
N 56720 -1130 56990 -1130 {lab=ctrl_p[63]}
N 57030 -860 57130 -860 {lab=ctrl_n[63]}
N 56930 -930 57070 -930 {lab=net1_63}
N 57070 -1030 57970 -1030 {lab=1.2V}
N 57030 -1230 57030 -860 {lab=ctrl_n[63]}
N 57010 -860 57030 -860 {lab=ctrl_n[63]}
N 57700 -830 57870 -830 {lab=Drain[64]}
N 57870 -830 57870 -740 {lab=Drain[64]}
N 57790 -740 57870 -740 {lab=Drain[64]}
N 57700 -830 57700 -740 {lab=Drain[64]}
N 57790 -740 57790 -670 {lab=Drain[64]}
N 57700 -740 57790 -740 {lab=Drain[64]}
N 57970 -670 58160 -670 {lab=Drain[64]}
N 57970 -670 57970 -510 {lab=Drain[64]}
N 58070 -830 58070 -740 {lab=Drain[64]}
N 58160 -740 58240 -740 {lab=Drain[64]}
N 58240 -830 58240 -740 {lab=Drain[64]}
N 58160 -740 58160 -670 {lab=Drain[64]}
N 58070 -740 58160 -740 {lab=Drain[64]}
N 57700 -970 57700 -890 {lab=Dsense}
N 57790 -970 57870 -970 {lab=Dsense}
N 57870 -970 57870 -890 {lab=Dsense}
N 58070 -970 58070 -890 {lab=Dforce}
N 58160 -970 58240 -970 {lab=Dforce}
N 58240 -970 58240 -890 {lab=Dforce}
N 57790 -1090 58690 -1090 {lab=Dsense}
N 57790 -1090 57790 -970 {lab=Dsense}
N 57700 -970 57790 -970 {lab=Dsense}
N 58160 -1060 59060 -1060 {lab=Dforce}
N 58160 -1060 58160 -970 {lab=Dforce}
N 58070 -970 58160 -970 {lab=Dforce}
N 58280 -860 58300 -860 {lab=ctrl_p[64]}
N 58300 -1130 58300 -860 {lab=ctrl_p[64]}
N 57890 -1230 57890 -1130 {lab=ctrl_p[64]}
N 57890 -1130 58300 -1130 {lab=ctrl_p[64]}
N 57620 -1130 57620 -860 {lab=ctrl_p[64]}
N 57620 -860 57660 -860 {lab=ctrl_p[64]}
N 58070 -860 58120 -860 {lab=net1_64}
N 57830 -860 57870 -860 {lab=net1_64}
N 57700 -860 57740 -860 {lab=net2_64}
N 58350 -1000 59250 -1000 {lab=Vss}
N 58190 -860 58240 -860 {lab=net2_64}
N 57970 -950 57970 -930 {lab=net1_64}
N 57970 -930 58120 -930 {lab=net1_64}
N 57830 -930 57830 -860 {lab=net1_64}
N 58120 -930 58120 -860 {lab=net1_64}
N 57970 -1030 57970 -1010 {lab=1.2V}
N 57740 -860 57740 -810 {lab=net2_64}
N 57740 -810 57970 -810 {lab=net2_64}
N 57970 -810 57970 -780 {lab=net2_64}
N 57970 -720 57970 -700 {lab=Vss}
N 57970 -700 58350 -700 {lab=Vss}
N 58350 -1000 58350 -700 {lab=Vss}
N 57790 -670 57970 -670 {lab=Drain[64]}
N 57970 -810 58190 -810 {lab=net2_64}
N 58190 -860 58190 -810 {lab=net2_64}
N 57620 -1130 57890 -1130 {lab=ctrl_p[64]}
N 57930 -860 58030 -860 {lab=ctrl_n[64]}
N 57830 -930 57970 -930 {lab=net1_64}
N 57970 -1030 58870 -1030 {lab=1.2V}
N 57930 -1230 57930 -860 {lab=ctrl_n[64]}
N 57910 -860 57930 -860 {lab=ctrl_n[64]}
N 58600 -830 58770 -830 {lab=Drain[65]}
N 58770 -830 58770 -740 {lab=Drain[65]}
N 58690 -740 58770 -740 {lab=Drain[65]}
N 58600 -830 58600 -740 {lab=Drain[65]}
N 58690 -740 58690 -670 {lab=Drain[65]}
N 58600 -740 58690 -740 {lab=Drain[65]}
N 58870 -670 59060 -670 {lab=Drain[65]}
N 58870 -670 58870 -510 {lab=Drain[65]}
N 58970 -830 58970 -740 {lab=Drain[65]}
N 59060 -740 59140 -740 {lab=Drain[65]}
N 59140 -830 59140 -740 {lab=Drain[65]}
N 59060 -740 59060 -670 {lab=Drain[65]}
N 58970 -740 59060 -740 {lab=Drain[65]}
N 58600 -970 58600 -890 {lab=Dsense}
N 58690 -970 58770 -970 {lab=Dsense}
N 58770 -970 58770 -890 {lab=Dsense}
N 58970 -970 58970 -890 {lab=Dforce}
N 59060 -970 59140 -970 {lab=Dforce}
N 59140 -970 59140 -890 {lab=Dforce}
N 58690 -1090 59590 -1090 {lab=Dsense}
N 58690 -1090 58690 -970 {lab=Dsense}
N 58600 -970 58690 -970 {lab=Dsense}
N 59060 -1060 59960 -1060 {lab=Dforce}
N 59060 -1060 59060 -970 {lab=Dforce}
N 58970 -970 59060 -970 {lab=Dforce}
N 59180 -860 59200 -860 {lab=ctrl_p[65]}
N 59200 -1130 59200 -860 {lab=ctrl_p[65]}
N 58790 -1230 58790 -1130 {lab=ctrl_p[65]}
N 58790 -1130 59200 -1130 {lab=ctrl_p[65]}
N 58520 -1130 58520 -860 {lab=ctrl_p[65]}
N 58520 -860 58560 -860 {lab=ctrl_p[65]}
N 58970 -860 59020 -860 {lab=net1_65}
N 58730 -860 58770 -860 {lab=net1_65}
N 58600 -860 58640 -860 {lab=net2_65}
N 59250 -1000 60150 -1000 {lab=Vss}
N 59090 -860 59140 -860 {lab=net2_65}
N 58870 -950 58870 -930 {lab=net1_65}
N 58870 -930 59020 -930 {lab=net1_65}
N 58730 -930 58730 -860 {lab=net1_65}
N 59020 -930 59020 -860 {lab=net1_65}
N 58870 -1030 58870 -1010 {lab=1.2V}
N 58640 -860 58640 -810 {lab=net2_65}
N 58640 -810 58870 -810 {lab=net2_65}
N 58870 -810 58870 -780 {lab=net2_65}
N 58870 -720 58870 -700 {lab=Vss}
N 58870 -700 59250 -700 {lab=Vss}
N 59250 -1000 59250 -700 {lab=Vss}
N 58690 -670 58870 -670 {lab=Drain[65]}
N 58870 -810 59090 -810 {lab=net2_65}
N 59090 -860 59090 -810 {lab=net2_65}
N 58520 -1130 58790 -1130 {lab=ctrl_p[65]}
N 58830 -860 58930 -860 {lab=ctrl_n[65]}
N 58730 -930 58870 -930 {lab=net1_65}
N 58870 -1030 59770 -1030 {lab=1.2V}
N 58830 -1230 58830 -860 {lab=ctrl_n[65]}
N 58810 -860 58830 -860 {lab=ctrl_n[65]}
N 59500 -830 59670 -830 {lab=Drain[66]}
N 59670 -830 59670 -740 {lab=Drain[66]}
N 59590 -740 59670 -740 {lab=Drain[66]}
N 59500 -830 59500 -740 {lab=Drain[66]}
N 59590 -740 59590 -670 {lab=Drain[66]}
N 59500 -740 59590 -740 {lab=Drain[66]}
N 59770 -670 59960 -670 {lab=Drain[66]}
N 59770 -670 59770 -510 {lab=Drain[66]}
N 59870 -830 59870 -740 {lab=Drain[66]}
N 59960 -740 60040 -740 {lab=Drain[66]}
N 60040 -830 60040 -740 {lab=Drain[66]}
N 59960 -740 59960 -670 {lab=Drain[66]}
N 59870 -740 59960 -740 {lab=Drain[66]}
N 59500 -970 59500 -890 {lab=Dsense}
N 59590 -970 59670 -970 {lab=Dsense}
N 59670 -970 59670 -890 {lab=Dsense}
N 59870 -970 59870 -890 {lab=Dforce}
N 59960 -970 60040 -970 {lab=Dforce}
N 60040 -970 60040 -890 {lab=Dforce}
N 59590 -1090 60490 -1090 {lab=Dsense}
N 59590 -1090 59590 -970 {lab=Dsense}
N 59500 -970 59590 -970 {lab=Dsense}
N 59960 -1060 60860 -1060 {lab=Dforce}
N 59960 -1060 59960 -970 {lab=Dforce}
N 59870 -970 59960 -970 {lab=Dforce}
N 60080 -860 60100 -860 {lab=ctrl_p[66]}
N 60100 -1130 60100 -860 {lab=ctrl_p[66]}
N 59690 -1230 59690 -1130 {lab=ctrl_p[66]}
N 59690 -1130 60100 -1130 {lab=ctrl_p[66]}
N 59420 -1130 59420 -860 {lab=ctrl_p[66]}
N 59420 -860 59460 -860 {lab=ctrl_p[66]}
N 59870 -860 59920 -860 {lab=net1_66}
N 59630 -860 59670 -860 {lab=net1_66}
N 59500 -860 59540 -860 {lab=net2_66}
N 60150 -1000 61050 -1000 {lab=Vss}
N 59990 -860 60040 -860 {lab=net2_66}
N 59770 -950 59770 -930 {lab=net1_66}
N 59770 -930 59920 -930 {lab=net1_66}
N 59630 -930 59630 -860 {lab=net1_66}
N 59920 -930 59920 -860 {lab=net1_66}
N 59770 -1030 59770 -1010 {lab=1.2V}
N 59540 -860 59540 -810 {lab=net2_66}
N 59540 -810 59770 -810 {lab=net2_66}
N 59770 -810 59770 -780 {lab=net2_66}
N 59770 -720 59770 -700 {lab=Vss}
N 59770 -700 60150 -700 {lab=Vss}
N 60150 -1000 60150 -700 {lab=Vss}
N 59590 -670 59770 -670 {lab=Drain[66]}
N 59770 -810 59990 -810 {lab=net2_66}
N 59990 -860 59990 -810 {lab=net2_66}
N 59420 -1130 59690 -1130 {lab=ctrl_p[66]}
N 59730 -860 59830 -860 {lab=ctrl_n[66]}
N 59630 -930 59770 -930 {lab=net1_66}
N 59770 -1030 60670 -1030 {lab=1.2V}
N 59730 -1230 59730 -860 {lab=ctrl_n[66]}
N 59710 -860 59730 -860 {lab=ctrl_n[66]}
N 60400 -830 60570 -830 {lab=Drain[67]}
N 60570 -830 60570 -740 {lab=Drain[67]}
N 60490 -740 60570 -740 {lab=Drain[67]}
N 60400 -830 60400 -740 {lab=Drain[67]}
N 60490 -740 60490 -670 {lab=Drain[67]}
N 60400 -740 60490 -740 {lab=Drain[67]}
N 60670 -670 60860 -670 {lab=Drain[67]}
N 60670 -670 60670 -510 {lab=Drain[67]}
N 60770 -830 60770 -740 {lab=Drain[67]}
N 60860 -740 60940 -740 {lab=Drain[67]}
N 60940 -830 60940 -740 {lab=Drain[67]}
N 60860 -740 60860 -670 {lab=Drain[67]}
N 60770 -740 60860 -740 {lab=Drain[67]}
N 60400 -970 60400 -890 {lab=Dsense}
N 60490 -970 60570 -970 {lab=Dsense}
N 60570 -970 60570 -890 {lab=Dsense}
N 60770 -970 60770 -890 {lab=Dforce}
N 60860 -970 60940 -970 {lab=Dforce}
N 60940 -970 60940 -890 {lab=Dforce}
N 60490 -1090 61390 -1090 {lab=Dsense}
N 60490 -1090 60490 -970 {lab=Dsense}
N 60400 -970 60490 -970 {lab=Dsense}
N 60860 -1060 61760 -1060 {lab=Dforce}
N 60860 -1060 60860 -970 {lab=Dforce}
N 60770 -970 60860 -970 {lab=Dforce}
N 60980 -860 61000 -860 {lab=ctrl_p[67]}
N 61000 -1130 61000 -860 {lab=ctrl_p[67]}
N 60590 -1230 60590 -1130 {lab=ctrl_p[67]}
N 60590 -1130 61000 -1130 {lab=ctrl_p[67]}
N 60320 -1130 60320 -860 {lab=ctrl_p[67]}
N 60320 -860 60360 -860 {lab=ctrl_p[67]}
N 60770 -860 60820 -860 {lab=net1_67}
N 60530 -860 60570 -860 {lab=net1_67}
N 60400 -860 60440 -860 {lab=net2_67}
N 61050 -1000 61950 -1000 {lab=Vss}
N 60890 -860 60940 -860 {lab=net2_67}
N 60670 -950 60670 -930 {lab=net1_67}
N 60670 -930 60820 -930 {lab=net1_67}
N 60530 -930 60530 -860 {lab=net1_67}
N 60820 -930 60820 -860 {lab=net1_67}
N 60670 -1030 60670 -1010 {lab=1.2V}
N 60440 -860 60440 -810 {lab=net2_67}
N 60440 -810 60670 -810 {lab=net2_67}
N 60670 -810 60670 -780 {lab=net2_67}
N 60670 -720 60670 -700 {lab=Vss}
N 60670 -700 61050 -700 {lab=Vss}
N 61050 -1000 61050 -700 {lab=Vss}
N 60490 -670 60670 -670 {lab=Drain[67]}
N 60670 -810 60890 -810 {lab=net2_67}
N 60890 -860 60890 -810 {lab=net2_67}
N 60320 -1130 60590 -1130 {lab=ctrl_p[67]}
N 60630 -860 60730 -860 {lab=ctrl_n[67]}
N 60530 -930 60670 -930 {lab=net1_67}
N 60670 -1030 61570 -1030 {lab=1.2V}
N 60630 -1230 60630 -860 {lab=ctrl_n[67]}
N 60610 -860 60630 -860 {lab=ctrl_n[67]}
N 61300 -830 61470 -830 {lab=Drain[68]}
N 61470 -830 61470 -740 {lab=Drain[68]}
N 61390 -740 61470 -740 {lab=Drain[68]}
N 61300 -830 61300 -740 {lab=Drain[68]}
N 61390 -740 61390 -670 {lab=Drain[68]}
N 61300 -740 61390 -740 {lab=Drain[68]}
N 61570 -670 61760 -670 {lab=Drain[68]}
N 61570 -670 61570 -510 {lab=Drain[68]}
N 61670 -830 61670 -740 {lab=Drain[68]}
N 61760 -740 61840 -740 {lab=Drain[68]}
N 61840 -830 61840 -740 {lab=Drain[68]}
N 61760 -740 61760 -670 {lab=Drain[68]}
N 61670 -740 61760 -740 {lab=Drain[68]}
N 61300 -970 61300 -890 {lab=Dsense}
N 61390 -970 61470 -970 {lab=Dsense}
N 61470 -970 61470 -890 {lab=Dsense}
N 61670 -970 61670 -890 {lab=Dforce}
N 61760 -970 61840 -970 {lab=Dforce}
N 61840 -970 61840 -890 {lab=Dforce}
N 61390 -1090 62290 -1090 {lab=Dsense}
N 61390 -1090 61390 -970 {lab=Dsense}
N 61300 -970 61390 -970 {lab=Dsense}
N 61760 -1060 62660 -1060 {lab=Dforce}
N 61760 -1060 61760 -970 {lab=Dforce}
N 61670 -970 61760 -970 {lab=Dforce}
N 61880 -860 61900 -860 {lab=ctrl_p[68]}
N 61900 -1130 61900 -860 {lab=ctrl_p[68]}
N 61490 -1230 61490 -1130 {lab=ctrl_p[68]}
N 61490 -1130 61900 -1130 {lab=ctrl_p[68]}
N 61220 -1130 61220 -860 {lab=ctrl_p[68]}
N 61220 -860 61260 -860 {lab=ctrl_p[68]}
N 61670 -860 61720 -860 {lab=net1_68}
N 61430 -860 61470 -860 {lab=net1_68}
N 61300 -860 61340 -860 {lab=net2_68}
N 61950 -1000 62850 -1000 {lab=Vss}
N 61790 -860 61840 -860 {lab=net2_68}
N 61570 -950 61570 -930 {lab=net1_68}
N 61570 -930 61720 -930 {lab=net1_68}
N 61430 -930 61430 -860 {lab=net1_68}
N 61720 -930 61720 -860 {lab=net1_68}
N 61570 -1030 61570 -1010 {lab=1.2V}
N 61340 -860 61340 -810 {lab=net2_68}
N 61340 -810 61570 -810 {lab=net2_68}
N 61570 -810 61570 -780 {lab=net2_68}
N 61570 -720 61570 -700 {lab=Vss}
N 61570 -700 61950 -700 {lab=Vss}
N 61950 -1000 61950 -700 {lab=Vss}
N 61390 -670 61570 -670 {lab=Drain[68]}
N 61570 -810 61790 -810 {lab=net2_68}
N 61790 -860 61790 -810 {lab=net2_68}
N 61220 -1130 61490 -1130 {lab=ctrl_p[68]}
N 61530 -860 61630 -860 {lab=ctrl_n[68]}
N 61430 -930 61570 -930 {lab=net1_68}
N 61570 -1030 62470 -1030 {lab=1.2V}
N 61530 -1230 61530 -860 {lab=ctrl_n[68]}
N 61510 -860 61530 -860 {lab=ctrl_n[68]}
N 62200 -830 62370 -830 {lab=Drain[69]}
N 62370 -830 62370 -740 {lab=Drain[69]}
N 62290 -740 62370 -740 {lab=Drain[69]}
N 62200 -830 62200 -740 {lab=Drain[69]}
N 62290 -740 62290 -670 {lab=Drain[69]}
N 62200 -740 62290 -740 {lab=Drain[69]}
N 62470 -670 62660 -670 {lab=Drain[69]}
N 62470 -670 62470 -510 {lab=Drain[69]}
N 62570 -830 62570 -740 {lab=Drain[69]}
N 62660 -740 62740 -740 {lab=Drain[69]}
N 62740 -830 62740 -740 {lab=Drain[69]}
N 62660 -740 62660 -670 {lab=Drain[69]}
N 62570 -740 62660 -740 {lab=Drain[69]}
N 62200 -970 62200 -890 {lab=Dsense}
N 62290 -970 62370 -970 {lab=Dsense}
N 62370 -970 62370 -890 {lab=Dsense}
N 62570 -970 62570 -890 {lab=Dforce}
N 62660 -970 62740 -970 {lab=Dforce}
N 62740 -970 62740 -890 {lab=Dforce}
N 62290 -1090 63190 -1090 {lab=Dsense}
N 62290 -1090 62290 -970 {lab=Dsense}
N 62200 -970 62290 -970 {lab=Dsense}
N 62660 -1060 63560 -1060 {lab=Dforce}
N 62660 -1060 62660 -970 {lab=Dforce}
N 62570 -970 62660 -970 {lab=Dforce}
N 62780 -860 62800 -860 {lab=ctrl_p[69]}
N 62800 -1130 62800 -860 {lab=ctrl_p[69]}
N 62390 -1230 62390 -1130 {lab=ctrl_p[69]}
N 62390 -1130 62800 -1130 {lab=ctrl_p[69]}
N 62120 -1130 62120 -860 {lab=ctrl_p[69]}
N 62120 -860 62160 -860 {lab=ctrl_p[69]}
N 62570 -860 62620 -860 {lab=net1_69}
N 62330 -860 62370 -860 {lab=net1_69}
N 62200 -860 62240 -860 {lab=net2_69}
N 62850 -1000 63750 -1000 {lab=Vss}
N 62690 -860 62740 -860 {lab=net2_69}
N 62470 -950 62470 -930 {lab=net1_69}
N 62470 -930 62620 -930 {lab=net1_69}
N 62330 -930 62330 -860 {lab=net1_69}
N 62620 -930 62620 -860 {lab=net1_69}
N 62470 -1030 62470 -1010 {lab=1.2V}
N 62240 -860 62240 -810 {lab=net2_69}
N 62240 -810 62470 -810 {lab=net2_69}
N 62470 -810 62470 -780 {lab=net2_69}
N 62470 -720 62470 -700 {lab=Vss}
N 62470 -700 62850 -700 {lab=Vss}
N 62850 -1000 62850 -700 {lab=Vss}
N 62290 -670 62470 -670 {lab=Drain[69]}
N 62470 -810 62690 -810 {lab=net2_69}
N 62690 -860 62690 -810 {lab=net2_69}
N 62120 -1130 62390 -1130 {lab=ctrl_p[69]}
N 62430 -860 62530 -860 {lab=ctrl_n[69]}
N 62330 -930 62470 -930 {lab=net1_69}
N 62470 -1030 63370 -1030 {lab=1.2V}
N 62430 -1230 62430 -860 {lab=ctrl_n[69]}
N 62410 -860 62430 -860 {lab=ctrl_n[69]}
N 63100 -830 63270 -830 {lab=Drain[70]}
N 63270 -830 63270 -740 {lab=Drain[70]}
N 63190 -740 63270 -740 {lab=Drain[70]}
N 63100 -830 63100 -740 {lab=Drain[70]}
N 63190 -740 63190 -670 {lab=Drain[70]}
N 63100 -740 63190 -740 {lab=Drain[70]}
N 63370 -670 63560 -670 {lab=Drain[70]}
N 63370 -670 63370 -510 {lab=Drain[70]}
N 63470 -830 63470 -740 {lab=Drain[70]}
N 63560 -740 63640 -740 {lab=Drain[70]}
N 63640 -830 63640 -740 {lab=Drain[70]}
N 63560 -740 63560 -670 {lab=Drain[70]}
N 63470 -740 63560 -740 {lab=Drain[70]}
N 63100 -970 63100 -890 {lab=Dsense}
N 63190 -970 63270 -970 {lab=Dsense}
N 63270 -970 63270 -890 {lab=Dsense}
N 63470 -970 63470 -890 {lab=Dforce}
N 63560 -970 63640 -970 {lab=Dforce}
N 63640 -970 63640 -890 {lab=Dforce}
N 63190 -1090 64090 -1090 {lab=Dsense}
N 63190 -1090 63190 -970 {lab=Dsense}
N 63100 -970 63190 -970 {lab=Dsense}
N 63560 -1060 64460 -1060 {lab=Dforce}
N 63560 -1060 63560 -970 {lab=Dforce}
N 63470 -970 63560 -970 {lab=Dforce}
N 63680 -860 63700 -860 {lab=ctrl_p[70]}
N 63700 -1130 63700 -860 {lab=ctrl_p[70]}
N 63290 -1230 63290 -1130 {lab=ctrl_p[70]}
N 63290 -1130 63700 -1130 {lab=ctrl_p[70]}
N 63020 -1130 63020 -860 {lab=ctrl_p[70]}
N 63020 -860 63060 -860 {lab=ctrl_p[70]}
N 63470 -860 63520 -860 {lab=net1_70}
N 63230 -860 63270 -860 {lab=net1_70}
N 63100 -860 63140 -860 {lab=net2_70}
N 63750 -1000 64650 -1000 {lab=Vss}
N 63590 -860 63640 -860 {lab=net2_70}
N 63370 -950 63370 -930 {lab=net1_70}
N 63370 -930 63520 -930 {lab=net1_70}
N 63230 -930 63230 -860 {lab=net1_70}
N 63520 -930 63520 -860 {lab=net1_70}
N 63370 -1030 63370 -1010 {lab=1.2V}
N 63140 -860 63140 -810 {lab=net2_70}
N 63140 -810 63370 -810 {lab=net2_70}
N 63370 -810 63370 -780 {lab=net2_70}
N 63370 -720 63370 -700 {lab=Vss}
N 63370 -700 63750 -700 {lab=Vss}
N 63750 -1000 63750 -700 {lab=Vss}
N 63190 -670 63370 -670 {lab=Drain[70]}
N 63370 -810 63590 -810 {lab=net2_70}
N 63590 -860 63590 -810 {lab=net2_70}
N 63020 -1130 63290 -1130 {lab=ctrl_p[70]}
N 63330 -860 63430 -860 {lab=ctrl_n[70]}
N 63230 -930 63370 -930 {lab=net1_70}
N 63370 -1030 64270 -1030 {lab=1.2V}
N 63330 -1230 63330 -860 {lab=ctrl_n[70]}
N 63310 -860 63330 -860 {lab=ctrl_n[70]}
N 64000 -830 64170 -830 {lab=Drain[71]}
N 64170 -830 64170 -740 {lab=Drain[71]}
N 64090 -740 64170 -740 {lab=Drain[71]}
N 64000 -830 64000 -740 {lab=Drain[71]}
N 64090 -740 64090 -670 {lab=Drain[71]}
N 64000 -740 64090 -740 {lab=Drain[71]}
N 64270 -670 64460 -670 {lab=Drain[71]}
N 64270 -670 64270 -510 {lab=Drain[71]}
N 64370 -830 64370 -740 {lab=Drain[71]}
N 64460 -740 64540 -740 {lab=Drain[71]}
N 64540 -830 64540 -740 {lab=Drain[71]}
N 64460 -740 64460 -670 {lab=Drain[71]}
N 64370 -740 64460 -740 {lab=Drain[71]}
N 64000 -970 64000 -890 {lab=Dsense}
N 64090 -970 64170 -970 {lab=Dsense}
N 64170 -970 64170 -890 {lab=Dsense}
N 64370 -970 64370 -890 {lab=Dforce}
N 64460 -970 64540 -970 {lab=Dforce}
N 64540 -970 64540 -890 {lab=Dforce}
N 64090 -1090 64990 -1090 {lab=Dsense}
N 64090 -1090 64090 -970 {lab=Dsense}
N 64000 -970 64090 -970 {lab=Dsense}
N 64460 -1060 65360 -1060 {lab=Dforce}
N 64460 -1060 64460 -970 {lab=Dforce}
N 64370 -970 64460 -970 {lab=Dforce}
N 64580 -860 64600 -860 {lab=ctrl_p[71]}
N 64600 -1130 64600 -860 {lab=ctrl_p[71]}
N 64190 -1230 64190 -1130 {lab=ctrl_p[71]}
N 64190 -1130 64600 -1130 {lab=ctrl_p[71]}
N 63920 -1130 63920 -860 {lab=ctrl_p[71]}
N 63920 -860 63960 -860 {lab=ctrl_p[71]}
N 64370 -860 64420 -860 {lab=net1_71}
N 64130 -860 64170 -860 {lab=net1_71}
N 64000 -860 64040 -860 {lab=net2_71}
N 64650 -1000 65550 -1000 {lab=Vss}
N 64490 -860 64540 -860 {lab=net2_71}
N 64270 -950 64270 -930 {lab=net1_71}
N 64270 -930 64420 -930 {lab=net1_71}
N 64130 -930 64130 -860 {lab=net1_71}
N 64420 -930 64420 -860 {lab=net1_71}
N 64270 -1030 64270 -1010 {lab=1.2V}
N 64040 -860 64040 -810 {lab=net2_71}
N 64040 -810 64270 -810 {lab=net2_71}
N 64270 -810 64270 -780 {lab=net2_71}
N 64270 -720 64270 -700 {lab=Vss}
N 64270 -700 64650 -700 {lab=Vss}
N 64650 -1000 64650 -700 {lab=Vss}
N 64090 -670 64270 -670 {lab=Drain[71]}
N 64270 -810 64490 -810 {lab=net2_71}
N 64490 -860 64490 -810 {lab=net2_71}
N 63920 -1130 64190 -1130 {lab=ctrl_p[71]}
N 64230 -860 64330 -860 {lab=ctrl_n[71]}
N 64130 -930 64270 -930 {lab=net1_71}
N 64270 -1030 65170 -1030 {lab=1.2V}
N 64230 -1230 64230 -860 {lab=ctrl_n[71]}
N 64210 -860 64230 -860 {lab=ctrl_n[71]}
N 64900 -830 65070 -830 {lab=Drain[72]}
N 65070 -830 65070 -740 {lab=Drain[72]}
N 64990 -740 65070 -740 {lab=Drain[72]}
N 64900 -830 64900 -740 {lab=Drain[72]}
N 64990 -740 64990 -670 {lab=Drain[72]}
N 64900 -740 64990 -740 {lab=Drain[72]}
N 65170 -670 65360 -670 {lab=Drain[72]}
N 65170 -670 65170 -510 {lab=Drain[72]}
N 65270 -830 65270 -740 {lab=Drain[72]}
N 65360 -740 65440 -740 {lab=Drain[72]}
N 65440 -830 65440 -740 {lab=Drain[72]}
N 65360 -740 65360 -670 {lab=Drain[72]}
N 65270 -740 65360 -740 {lab=Drain[72]}
N 64900 -970 64900 -890 {lab=Dsense}
N 64990 -970 65070 -970 {lab=Dsense}
N 65070 -970 65070 -890 {lab=Dsense}
N 65270 -970 65270 -890 {lab=Dforce}
N 65360 -970 65440 -970 {lab=Dforce}
N 65440 -970 65440 -890 {lab=Dforce}
N 64990 -1090 65890 -1090 {lab=Dsense}
N 64990 -1090 64990 -970 {lab=Dsense}
N 64900 -970 64990 -970 {lab=Dsense}
N 65360 -1060 66260 -1060 {lab=Dforce}
N 65360 -1060 65360 -970 {lab=Dforce}
N 65270 -970 65360 -970 {lab=Dforce}
N 65480 -860 65500 -860 {lab=ctrl_p[72]}
N 65500 -1130 65500 -860 {lab=ctrl_p[72]}
N 65090 -1230 65090 -1130 {lab=ctrl_p[72]}
N 65090 -1130 65500 -1130 {lab=ctrl_p[72]}
N 64820 -1130 64820 -860 {lab=ctrl_p[72]}
N 64820 -860 64860 -860 {lab=ctrl_p[72]}
N 65270 -860 65320 -860 {lab=net1_72}
N 65030 -860 65070 -860 {lab=net1_72}
N 64900 -860 64940 -860 {lab=net2_72}
N 65550 -1000 66450 -1000 {lab=Vss}
N 65390 -860 65440 -860 {lab=net2_72}
N 65170 -950 65170 -930 {lab=net1_72}
N 65170 -930 65320 -930 {lab=net1_72}
N 65030 -930 65030 -860 {lab=net1_72}
N 65320 -930 65320 -860 {lab=net1_72}
N 65170 -1030 65170 -1010 {lab=1.2V}
N 64940 -860 64940 -810 {lab=net2_72}
N 64940 -810 65170 -810 {lab=net2_72}
N 65170 -810 65170 -780 {lab=net2_72}
N 65170 -720 65170 -700 {lab=Vss}
N 65170 -700 65550 -700 {lab=Vss}
N 65550 -1000 65550 -700 {lab=Vss}
N 64990 -670 65170 -670 {lab=Drain[72]}
N 65170 -810 65390 -810 {lab=net2_72}
N 65390 -860 65390 -810 {lab=net2_72}
N 64820 -1130 65090 -1130 {lab=ctrl_p[72]}
N 65130 -860 65230 -860 {lab=ctrl_n[72]}
N 65030 -930 65170 -930 {lab=net1_72}
N 65170 -1030 66070 -1030 {lab=1.2V}
N 65130 -1230 65130 -860 {lab=ctrl_n[72]}
N 65110 -860 65130 -860 {lab=ctrl_n[72]}
N 65800 -830 65970 -830 {lab=Drain[73]}
N 65970 -830 65970 -740 {lab=Drain[73]}
N 65890 -740 65970 -740 {lab=Drain[73]}
N 65800 -830 65800 -740 {lab=Drain[73]}
N 65890 -740 65890 -670 {lab=Drain[73]}
N 65800 -740 65890 -740 {lab=Drain[73]}
N 66070 -670 66260 -670 {lab=Drain[73]}
N 66070 -670 66070 -510 {lab=Drain[73]}
N 66170 -830 66170 -740 {lab=Drain[73]}
N 66260 -740 66340 -740 {lab=Drain[73]}
N 66340 -830 66340 -740 {lab=Drain[73]}
N 66260 -740 66260 -670 {lab=Drain[73]}
N 66170 -740 66260 -740 {lab=Drain[73]}
N 65800 -970 65800 -890 {lab=Dsense}
N 65890 -970 65970 -970 {lab=Dsense}
N 65970 -970 65970 -890 {lab=Dsense}
N 66170 -970 66170 -890 {lab=Dforce}
N 66260 -970 66340 -970 {lab=Dforce}
N 66340 -970 66340 -890 {lab=Dforce}
N 65890 -1090 66790 -1090 {lab=Dsense}
N 65890 -1090 65890 -970 {lab=Dsense}
N 65800 -970 65890 -970 {lab=Dsense}
N 66260 -1060 67160 -1060 {lab=Dforce}
N 66260 -1060 66260 -970 {lab=Dforce}
N 66170 -970 66260 -970 {lab=Dforce}
N 66380 -860 66400 -860 {lab=ctrl_p[73]}
N 66400 -1130 66400 -860 {lab=ctrl_p[73]}
N 65990 -1230 65990 -1130 {lab=ctrl_p[73]}
N 65990 -1130 66400 -1130 {lab=ctrl_p[73]}
N 65720 -1130 65720 -860 {lab=ctrl_p[73]}
N 65720 -860 65760 -860 {lab=ctrl_p[73]}
N 66170 -860 66220 -860 {lab=net1_73}
N 65930 -860 65970 -860 {lab=net1_73}
N 65800 -860 65840 -860 {lab=net2_73}
N 66450 -1000 67350 -1000 {lab=Vss}
N 66290 -860 66340 -860 {lab=net2_73}
N 66070 -950 66070 -930 {lab=net1_73}
N 66070 -930 66220 -930 {lab=net1_73}
N 65930 -930 65930 -860 {lab=net1_73}
N 66220 -930 66220 -860 {lab=net1_73}
N 66070 -1030 66070 -1010 {lab=1.2V}
N 65840 -860 65840 -810 {lab=net2_73}
N 65840 -810 66070 -810 {lab=net2_73}
N 66070 -810 66070 -780 {lab=net2_73}
N 66070 -720 66070 -700 {lab=Vss}
N 66070 -700 66450 -700 {lab=Vss}
N 66450 -1000 66450 -700 {lab=Vss}
N 65890 -670 66070 -670 {lab=Drain[73]}
N 66070 -810 66290 -810 {lab=net2_73}
N 66290 -860 66290 -810 {lab=net2_73}
N 65720 -1130 65990 -1130 {lab=ctrl_p[73]}
N 66030 -860 66130 -860 {lab=ctrl_n[73]}
N 65930 -930 66070 -930 {lab=net1_73}
N 66070 -1030 66970 -1030 {lab=1.2V}
N 66030 -1230 66030 -860 {lab=ctrl_n[73]}
N 66010 -860 66030 -860 {lab=ctrl_n[73]}
N 66700 -830 66870 -830 {lab=Drain[74]}
N 66870 -830 66870 -740 {lab=Drain[74]}
N 66790 -740 66870 -740 {lab=Drain[74]}
N 66700 -830 66700 -740 {lab=Drain[74]}
N 66790 -740 66790 -670 {lab=Drain[74]}
N 66700 -740 66790 -740 {lab=Drain[74]}
N 66970 -670 67160 -670 {lab=Drain[74]}
N 66970 -670 66970 -510 {lab=Drain[74]}
N 67070 -830 67070 -740 {lab=Drain[74]}
N 67160 -740 67240 -740 {lab=Drain[74]}
N 67240 -830 67240 -740 {lab=Drain[74]}
N 67160 -740 67160 -670 {lab=Drain[74]}
N 67070 -740 67160 -740 {lab=Drain[74]}
N 66700 -970 66700 -890 {lab=Dsense}
N 66790 -970 66870 -970 {lab=Dsense}
N 66870 -970 66870 -890 {lab=Dsense}
N 67070 -970 67070 -890 {lab=Dforce}
N 67160 -970 67240 -970 {lab=Dforce}
N 67240 -970 67240 -890 {lab=Dforce}
N 66790 -1090 67690 -1090 {lab=Dsense}
N 66790 -1090 66790 -970 {lab=Dsense}
N 66700 -970 66790 -970 {lab=Dsense}
N 67160 -1060 68060 -1060 {lab=Dforce}
N 67160 -1060 67160 -970 {lab=Dforce}
N 67070 -970 67160 -970 {lab=Dforce}
N 67280 -860 67300 -860 {lab=ctrl_p[74]}
N 67300 -1130 67300 -860 {lab=ctrl_p[74]}
N 66890 -1230 66890 -1130 {lab=ctrl_p[74]}
N 66890 -1130 67300 -1130 {lab=ctrl_p[74]}
N 66620 -1130 66620 -860 {lab=ctrl_p[74]}
N 66620 -860 66660 -860 {lab=ctrl_p[74]}
N 67070 -860 67120 -860 {lab=net1_74}
N 66830 -860 66870 -860 {lab=net1_74}
N 66700 -860 66740 -860 {lab=net2_74}
N 67350 -1000 68250 -1000 {lab=Vss}
N 67190 -860 67240 -860 {lab=net2_74}
N 66970 -950 66970 -930 {lab=net1_74}
N 66970 -930 67120 -930 {lab=net1_74}
N 66830 -930 66830 -860 {lab=net1_74}
N 67120 -930 67120 -860 {lab=net1_74}
N 66970 -1030 66970 -1010 {lab=1.2V}
N 66740 -860 66740 -810 {lab=net2_74}
N 66740 -810 66970 -810 {lab=net2_74}
N 66970 -810 66970 -780 {lab=net2_74}
N 66970 -720 66970 -700 {lab=Vss}
N 66970 -700 67350 -700 {lab=Vss}
N 67350 -1000 67350 -700 {lab=Vss}
N 66790 -670 66970 -670 {lab=Drain[74]}
N 66970 -810 67190 -810 {lab=net2_74}
N 67190 -860 67190 -810 {lab=net2_74}
N 66620 -1130 66890 -1130 {lab=ctrl_p[74]}
N 66930 -860 67030 -860 {lab=ctrl_n[74]}
N 66830 -930 66970 -930 {lab=net1_74}
N 66970 -1030 67870 -1030 {lab=1.2V}
N 66930 -1230 66930 -860 {lab=ctrl_n[74]}
N 66910 -860 66930 -860 {lab=ctrl_n[74]}
N 67600 -830 67770 -830 {lab=Drain[75]}
N 67770 -830 67770 -740 {lab=Drain[75]}
N 67690 -740 67770 -740 {lab=Drain[75]}
N 67600 -830 67600 -740 {lab=Drain[75]}
N 67690 -740 67690 -670 {lab=Drain[75]}
N 67600 -740 67690 -740 {lab=Drain[75]}
N 67870 -670 68060 -670 {lab=Drain[75]}
N 67870 -670 67870 -510 {lab=Drain[75]}
N 67970 -830 67970 -740 {lab=Drain[75]}
N 68060 -740 68140 -740 {lab=Drain[75]}
N 68140 -830 68140 -740 {lab=Drain[75]}
N 68060 -740 68060 -670 {lab=Drain[75]}
N 67970 -740 68060 -740 {lab=Drain[75]}
N 67600 -970 67600 -890 {lab=Dsense}
N 67690 -970 67770 -970 {lab=Dsense}
N 67770 -970 67770 -890 {lab=Dsense}
N 67970 -970 67970 -890 {lab=Dforce}
N 68060 -970 68140 -970 {lab=Dforce}
N 68140 -970 68140 -890 {lab=Dforce}
N 67690 -1090 68590 -1090 {lab=Dsense}
N 67690 -1090 67690 -970 {lab=Dsense}
N 67600 -970 67690 -970 {lab=Dsense}
N 68060 -1060 68960 -1060 {lab=Dforce}
N 68060 -1060 68060 -970 {lab=Dforce}
N 67970 -970 68060 -970 {lab=Dforce}
N 68180 -860 68200 -860 {lab=ctrl_p[75]}
N 68200 -1130 68200 -860 {lab=ctrl_p[75]}
N 67790 -1230 67790 -1130 {lab=ctrl_p[75]}
N 67790 -1130 68200 -1130 {lab=ctrl_p[75]}
N 67520 -1130 67520 -860 {lab=ctrl_p[75]}
N 67520 -860 67560 -860 {lab=ctrl_p[75]}
N 67970 -860 68020 -860 {lab=net1_75}
N 67730 -860 67770 -860 {lab=net1_75}
N 67600 -860 67640 -860 {lab=net2_75}
N 68250 -1000 69150 -1000 {lab=Vss}
N 68090 -860 68140 -860 {lab=net2_75}
N 67870 -950 67870 -930 {lab=net1_75}
N 67870 -930 68020 -930 {lab=net1_75}
N 67730 -930 67730 -860 {lab=net1_75}
N 68020 -930 68020 -860 {lab=net1_75}
N 67870 -1030 67870 -1010 {lab=1.2V}
N 67640 -860 67640 -810 {lab=net2_75}
N 67640 -810 67870 -810 {lab=net2_75}
N 67870 -810 67870 -780 {lab=net2_75}
N 67870 -720 67870 -700 {lab=Vss}
N 67870 -700 68250 -700 {lab=Vss}
N 68250 -1000 68250 -700 {lab=Vss}
N 67690 -670 67870 -670 {lab=Drain[75]}
N 67870 -810 68090 -810 {lab=net2_75}
N 68090 -860 68090 -810 {lab=net2_75}
N 67520 -1130 67790 -1130 {lab=ctrl_p[75]}
N 67830 -860 67930 -860 {lab=ctrl_n[75]}
N 67730 -930 67870 -930 {lab=net1_75}
N 67870 -1030 68770 -1030 {lab=1.2V}
N 67830 -1230 67830 -860 {lab=ctrl_n[75]}
N 67810 -860 67830 -860 {lab=ctrl_n[75]}
N 68500 -830 68670 -830 {lab=Drain[76]}
N 68670 -830 68670 -740 {lab=Drain[76]}
N 68590 -740 68670 -740 {lab=Drain[76]}
N 68500 -830 68500 -740 {lab=Drain[76]}
N 68590 -740 68590 -670 {lab=Drain[76]}
N 68500 -740 68590 -740 {lab=Drain[76]}
N 68770 -670 68960 -670 {lab=Drain[76]}
N 68770 -670 68770 -510 {lab=Drain[76]}
N 68870 -830 68870 -740 {lab=Drain[76]}
N 68960 -740 69040 -740 {lab=Drain[76]}
N 69040 -830 69040 -740 {lab=Drain[76]}
N 68960 -740 68960 -670 {lab=Drain[76]}
N 68870 -740 68960 -740 {lab=Drain[76]}
N 68500 -970 68500 -890 {lab=Dsense}
N 68590 -970 68670 -970 {lab=Dsense}
N 68670 -970 68670 -890 {lab=Dsense}
N 68870 -970 68870 -890 {lab=Dforce}
N 68960 -970 69040 -970 {lab=Dforce}
N 69040 -970 69040 -890 {lab=Dforce}
N 68590 -1090 69490 -1090 {lab=Dsense}
N 68590 -1090 68590 -970 {lab=Dsense}
N 68500 -970 68590 -970 {lab=Dsense}
N 68960 -1060 69860 -1060 {lab=Dforce}
N 68960 -1060 68960 -970 {lab=Dforce}
N 68870 -970 68960 -970 {lab=Dforce}
N 69080 -860 69100 -860 {lab=ctrl_p[76]}
N 69100 -1130 69100 -860 {lab=ctrl_p[76]}
N 68690 -1230 68690 -1130 {lab=ctrl_p[76]}
N 68690 -1130 69100 -1130 {lab=ctrl_p[76]}
N 68420 -1130 68420 -860 {lab=ctrl_p[76]}
N 68420 -860 68460 -860 {lab=ctrl_p[76]}
N 68870 -860 68920 -860 {lab=net1_76}
N 68630 -860 68670 -860 {lab=net1_76}
N 68500 -860 68540 -860 {lab=net2_76}
N 69150 -1000 70050 -1000 {lab=Vss}
N 68990 -860 69040 -860 {lab=net2_76}
N 68770 -950 68770 -930 {lab=net1_76}
N 68770 -930 68920 -930 {lab=net1_76}
N 68630 -930 68630 -860 {lab=net1_76}
N 68920 -930 68920 -860 {lab=net1_76}
N 68770 -1030 68770 -1010 {lab=1.2V}
N 68540 -860 68540 -810 {lab=net2_76}
N 68540 -810 68770 -810 {lab=net2_76}
N 68770 -810 68770 -780 {lab=net2_76}
N 68770 -720 68770 -700 {lab=Vss}
N 68770 -700 69150 -700 {lab=Vss}
N 69150 -1000 69150 -700 {lab=Vss}
N 68590 -670 68770 -670 {lab=Drain[76]}
N 68770 -810 68990 -810 {lab=net2_76}
N 68990 -860 68990 -810 {lab=net2_76}
N 68420 -1130 68690 -1130 {lab=ctrl_p[76]}
N 68730 -860 68830 -860 {lab=ctrl_n[76]}
N 68630 -930 68770 -930 {lab=net1_76}
N 68770 -1030 69670 -1030 {lab=1.2V}
N 68730 -1230 68730 -860 {lab=ctrl_n[76]}
N 68710 -860 68730 -860 {lab=ctrl_n[76]}
N 69400 -830 69570 -830 {lab=Drain[77]}
N 69570 -830 69570 -740 {lab=Drain[77]}
N 69490 -740 69570 -740 {lab=Drain[77]}
N 69400 -830 69400 -740 {lab=Drain[77]}
N 69490 -740 69490 -670 {lab=Drain[77]}
N 69400 -740 69490 -740 {lab=Drain[77]}
N 69670 -670 69860 -670 {lab=Drain[77]}
N 69670 -670 69670 -510 {lab=Drain[77]}
N 69770 -830 69770 -740 {lab=Drain[77]}
N 69860 -740 69940 -740 {lab=Drain[77]}
N 69940 -830 69940 -740 {lab=Drain[77]}
N 69860 -740 69860 -670 {lab=Drain[77]}
N 69770 -740 69860 -740 {lab=Drain[77]}
N 69400 -970 69400 -890 {lab=Dsense}
N 69490 -970 69570 -970 {lab=Dsense}
N 69570 -970 69570 -890 {lab=Dsense}
N 69770 -970 69770 -890 {lab=Dforce}
N 69860 -970 69940 -970 {lab=Dforce}
N 69940 -970 69940 -890 {lab=Dforce}
N 69490 -1090 70390 -1090 {lab=Dsense}
N 69490 -1090 69490 -970 {lab=Dsense}
N 69400 -970 69490 -970 {lab=Dsense}
N 69860 -1060 70760 -1060 {lab=Dforce}
N 69860 -1060 69860 -970 {lab=Dforce}
N 69770 -970 69860 -970 {lab=Dforce}
N 69980 -860 70000 -860 {lab=ctrl_p[77]}
N 70000 -1130 70000 -860 {lab=ctrl_p[77]}
N 69590 -1230 69590 -1130 {lab=ctrl_p[77]}
N 69590 -1130 70000 -1130 {lab=ctrl_p[77]}
N 69320 -1130 69320 -860 {lab=ctrl_p[77]}
N 69320 -860 69360 -860 {lab=ctrl_p[77]}
N 69770 -860 69820 -860 {lab=net1_77}
N 69530 -860 69570 -860 {lab=net1_77}
N 69400 -860 69440 -860 {lab=net2_77}
N 70050 -1000 70950 -1000 {lab=Vss}
N 69890 -860 69940 -860 {lab=net2_77}
N 69670 -950 69670 -930 {lab=net1_77}
N 69670 -930 69820 -930 {lab=net1_77}
N 69530 -930 69530 -860 {lab=net1_77}
N 69820 -930 69820 -860 {lab=net1_77}
N 69670 -1030 69670 -1010 {lab=1.2V}
N 69440 -860 69440 -810 {lab=net2_77}
N 69440 -810 69670 -810 {lab=net2_77}
N 69670 -810 69670 -780 {lab=net2_77}
N 69670 -720 69670 -700 {lab=Vss}
N 69670 -700 70050 -700 {lab=Vss}
N 70050 -1000 70050 -700 {lab=Vss}
N 69490 -670 69670 -670 {lab=Drain[77]}
N 69670 -810 69890 -810 {lab=net2_77}
N 69890 -860 69890 -810 {lab=net2_77}
N 69320 -1130 69590 -1130 {lab=ctrl_p[77]}
N 69630 -860 69730 -860 {lab=ctrl_n[77]}
N 69530 -930 69670 -930 {lab=net1_77}
N 69670 -1030 70570 -1030 {lab=1.2V}
N 69630 -1230 69630 -860 {lab=ctrl_n[77]}
N 69610 -860 69630 -860 {lab=ctrl_n[77]}
N 70300 -830 70470 -830 {lab=Drain[78]}
N 70470 -830 70470 -740 {lab=Drain[78]}
N 70390 -740 70470 -740 {lab=Drain[78]}
N 70300 -830 70300 -740 {lab=Drain[78]}
N 70390 -740 70390 -670 {lab=Drain[78]}
N 70300 -740 70390 -740 {lab=Drain[78]}
N 70570 -670 70760 -670 {lab=Drain[78]}
N 70570 -670 70570 -510 {lab=Drain[78]}
N 70670 -830 70670 -740 {lab=Drain[78]}
N 70760 -740 70840 -740 {lab=Drain[78]}
N 70840 -830 70840 -740 {lab=Drain[78]}
N 70760 -740 70760 -670 {lab=Drain[78]}
N 70670 -740 70760 -740 {lab=Drain[78]}
N 70300 -970 70300 -890 {lab=Dsense}
N 70390 -970 70470 -970 {lab=Dsense}
N 70470 -970 70470 -890 {lab=Dsense}
N 70670 -970 70670 -890 {lab=Dforce}
N 70760 -970 70840 -970 {lab=Dforce}
N 70840 -970 70840 -890 {lab=Dforce}
N 70390 -1090 71290 -1090 {lab=Dsense}
N 70390 -1090 70390 -970 {lab=Dsense}
N 70300 -970 70390 -970 {lab=Dsense}
N 70760 -1060 71660 -1060 {lab=Dforce}
N 70760 -1060 70760 -970 {lab=Dforce}
N 70670 -970 70760 -970 {lab=Dforce}
N 70880 -860 70900 -860 {lab=ctrl_p[78]}
N 70900 -1130 70900 -860 {lab=ctrl_p[78]}
N 70490 -1230 70490 -1130 {lab=ctrl_p[78]}
N 70490 -1130 70900 -1130 {lab=ctrl_p[78]}
N 70220 -1130 70220 -860 {lab=ctrl_p[78]}
N 70220 -860 70260 -860 {lab=ctrl_p[78]}
N 70670 -860 70720 -860 {lab=net1_78}
N 70430 -860 70470 -860 {lab=net1_78}
N 70300 -860 70340 -860 {lab=net2_78}
N 70950 -1000 71850 -1000 {lab=Vss}
N 70790 -860 70840 -860 {lab=net2_78}
N 70570 -950 70570 -930 {lab=net1_78}
N 70570 -930 70720 -930 {lab=net1_78}
N 70430 -930 70430 -860 {lab=net1_78}
N 70720 -930 70720 -860 {lab=net1_78}
N 70570 -1030 70570 -1010 {lab=1.2V}
N 70340 -860 70340 -810 {lab=net2_78}
N 70340 -810 70570 -810 {lab=net2_78}
N 70570 -810 70570 -780 {lab=net2_78}
N 70570 -720 70570 -700 {lab=Vss}
N 70570 -700 70950 -700 {lab=Vss}
N 70950 -1000 70950 -700 {lab=Vss}
N 70390 -670 70570 -670 {lab=Drain[78]}
N 70570 -810 70790 -810 {lab=net2_78}
N 70790 -860 70790 -810 {lab=net2_78}
N 70220 -1130 70490 -1130 {lab=ctrl_p[78]}
N 70530 -860 70630 -860 {lab=ctrl_n[78]}
N 70430 -930 70570 -930 {lab=net1_78}
N 70570 -1030 71470 -1030 {lab=1.2V}
N 70530 -1230 70530 -860 {lab=ctrl_n[78]}
N 70510 -860 70530 -860 {lab=ctrl_n[78]}
N 71200 -830 71370 -830 {lab=Drain[79]}
N 71370 -830 71370 -740 {lab=Drain[79]}
N 71290 -740 71370 -740 {lab=Drain[79]}
N 71200 -830 71200 -740 {lab=Drain[79]}
N 71290 -740 71290 -670 {lab=Drain[79]}
N 71200 -740 71290 -740 {lab=Drain[79]}
N 71470 -670 71660 -670 {lab=Drain[79]}
N 71470 -670 71470 -510 {lab=Drain[79]}
N 71570 -830 71570 -740 {lab=Drain[79]}
N 71660 -740 71740 -740 {lab=Drain[79]}
N 71740 -830 71740 -740 {lab=Drain[79]}
N 71660 -740 71660 -670 {lab=Drain[79]}
N 71570 -740 71660 -740 {lab=Drain[79]}
N 71200 -970 71200 -890 {lab=Dsense}
N 71290 -970 71370 -970 {lab=Dsense}
N 71370 -970 71370 -890 {lab=Dsense}
N 71570 -970 71570 -890 {lab=Dforce}
N 71660 -970 71740 -970 {lab=Dforce}
N 71740 -970 71740 -890 {lab=Dforce}
N 71290 -1090 71860 -1090 {lab=Dsense}
N 71290 -1090 71290 -970 {lab=Dsense}
N 71200 -970 71290 -970 {lab=Dsense}
N 71660 -1060 71860 -1060 {lab=Dforce}
N 71660 -1060 71660 -970 {lab=Dforce}
N 71570 -970 71660 -970 {lab=Dforce}
N 71780 -860 71800 -860 {lab=ctrl_p[79]}
N 71800 -1130 71800 -860 {lab=ctrl_p[79]}
N 71390 -1230 71390 -1130 {lab=ctrl_p[79]}
N 71390 -1130 71800 -1130 {lab=ctrl_p[79]}
N 71120 -1130 71120 -860 {lab=ctrl_p[79]}
N 71120 -860 71160 -860 {lab=ctrl_p[79]}
N 71570 -860 71620 -860 {lab=net1_79}
N 71330 -860 71370 -860 {lab=net1_79}
N 71200 -860 71240 -860 {lab=net2_79}
N 71850 -1000 71860 -1000 {lab=Vss}
N 71690 -860 71740 -860 {lab=net2_79}
N 71470 -950 71470 -930 {lab=net1_79}
N 71470 -930 71620 -930 {lab=net1_79}
N 71330 -930 71330 -860 {lab=net1_79}
N 71620 -930 71620 -860 {lab=net1_79}
N 71470 -1030 71470 -1010 {lab=1.2V}
N 71240 -860 71240 -810 {lab=net2_79}
N 71240 -810 71470 -810 {lab=net2_79}
N 71470 -810 71470 -780 {lab=net2_79}
N 71470 -720 71470 -700 {lab=Vss}
N 71470 -700 71850 -700 {lab=Vss}
N 71850 -1000 71850 -700 {lab=Vss}
N 71290 -670 71470 -670 {lab=Drain[79]}
N 71470 -810 71690 -810 {lab=net2_79}
N 71690 -860 71690 -810 {lab=net2_79}
N 71120 -1130 71390 -1130 {lab=ctrl_p[79]}
N 71430 -860 71530 -860 {lab=ctrl_n[79]}
N 71330 -930 71470 -930 {lab=net1_79}
N 71470 -1030 71860 -1030 {lab=1.2V}
N 71430 -1230 71430 -860 {lab=ctrl_n[79]}
N 71410 -860 71430 -860 {lab=ctrl_n[79]}
N 510 -1060 560 -1060 {lab=Dforce}
N 510 -1000 750 -1000 {lab=Vss}
N 190 -1090 1090 -1090 {lab=Dsense}
N 370 -1030 1270 -1030 {lab=1.2V}
C {devices/ipin.sym} -500 -1250 0 0 {name=p_ctrlp lab=ctrl_p[79:0]}
C {devices/ipin.sym} -500 -1210 0 0 {name=p_ctrln lab=ctrl_n[79:0]}
C {devices/iopin.sym} -500 -1170 0 0 {name=p_drain lab=Drain[79:0]}
C {sg13g2_pr/sg13_lv_nmos.sym} 80 -860 0 0 {name=M4_00 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 290 -860 0 1 {name=M8_00 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 450 -860 0 0 {name=M9_00 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 660 -860 0 1 {name=M10_00 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 370 -750 2 0 {name=R1_00 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 370 -980 2 0 {name=R2_00 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 370 -510 0 0 {name=lp_Drain[0] lab=Drain[0]}
C {devices/lab_pin.sym} 290 -1230 0 0 {name=lp_ctrl_p[0] lab=ctrl_p[0]}
C {devices/lab_pin.sym} 330 -1230 0 0 {name=lp_ctrl_n[0] lab=ctrl_n[0]}
C {sg13g2_pr/sg13_lv_nmos.sym} 980 -860 0 0 {name=M4_01 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 1190 -860 0 1 {name=M8_01 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 1350 -860 0 0 {name=M9_01 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 1560 -860 0 1 {name=M10_01 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 1270 -750 2 0 {name=R1_01 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 1270 -980 2 0 {name=R2_01 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 1270 -510 0 0 {name=lp_Drain[1] lab=Drain[1]}
C {devices/lab_pin.sym} 1190 -1230 0 0 {name=lp_ctrl_p[1] lab=ctrl_p[1]}
C {devices/lab_pin.sym} 1230 -1230 0 0 {name=lp_ctrl_n[1] lab=ctrl_n[1]}
C {sg13g2_pr/sg13_lv_nmos.sym} 1880 -860 0 0 {name=M4_02 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 2090 -860 0 1 {name=M8_02 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 2250 -860 0 0 {name=M9_02 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 2460 -860 0 1 {name=M10_02 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 2170 -750 2 0 {name=R1_02 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 2170 -980 2 0 {name=R2_02 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 2170 -510 0 0 {name=lp_Drain[2] lab=Drain[2]}
C {devices/lab_pin.sym} 2090 -1230 0 0 {name=lp_ctrl_p[2] lab=ctrl_p[2]}
C {devices/lab_pin.sym} 2130 -1230 0 0 {name=lp_ctrl_n[2] lab=ctrl_n[2]}
C {sg13g2_pr/sg13_lv_nmos.sym} 2780 -860 0 0 {name=M4_03 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 2990 -860 0 1 {name=M8_03 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 3150 -860 0 0 {name=M9_03 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 3360 -860 0 1 {name=M10_03 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 3070 -750 2 0 {name=R1_03 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 3070 -980 2 0 {name=R2_03 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 3070 -510 0 0 {name=lp_Drain[3] lab=Drain[3]}
C {devices/lab_pin.sym} 2990 -1230 0 0 {name=lp_ctrl_p[3] lab=ctrl_p[3]}
C {devices/lab_pin.sym} 3030 -1230 0 0 {name=lp_ctrl_n[3] lab=ctrl_n[3]}
C {sg13g2_pr/sg13_lv_nmos.sym} 3680 -860 0 0 {name=M4_04 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 3890 -860 0 1 {name=M8_04 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 4050 -860 0 0 {name=M9_04 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 4260 -860 0 1 {name=M10_04 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 3970 -750 2 0 {name=R1_04 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 3970 -980 2 0 {name=R2_04 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 3970 -510 0 0 {name=lp_Drain[4] lab=Drain[4]}
C {devices/lab_pin.sym} 3890 -1230 0 0 {name=lp_ctrl_p[4] lab=ctrl_p[4]}
C {devices/lab_pin.sym} 3930 -1230 0 0 {name=lp_ctrl_n[4] lab=ctrl_n[4]}
C {sg13g2_pr/sg13_lv_nmos.sym} 4580 -860 0 0 {name=M4_05 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 4790 -860 0 1 {name=M8_05 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 4950 -860 0 0 {name=M9_05 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 5160 -860 0 1 {name=M10_05 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 4870 -750 2 0 {name=R1_05 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 4870 -980 2 0 {name=R2_05 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 4870 -510 0 0 {name=lp_Drain[5] lab=Drain[5]}
C {devices/lab_pin.sym} 4790 -1230 0 0 {name=lp_ctrl_p[5] lab=ctrl_p[5]}
C {devices/lab_pin.sym} 4830 -1230 0 0 {name=lp_ctrl_n[5] lab=ctrl_n[5]}
C {sg13g2_pr/sg13_lv_nmos.sym} 5480 -860 0 0 {name=M4_06 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 5690 -860 0 1 {name=M8_06 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 5850 -860 0 0 {name=M9_06 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 6060 -860 0 1 {name=M10_06 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 5770 -750 2 0 {name=R1_06 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 5770 -980 2 0 {name=R2_06 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 5770 -510 0 0 {name=lp_Drain[6] lab=Drain[6]}
C {devices/lab_pin.sym} 5690 -1230 0 0 {name=lp_ctrl_p[6] lab=ctrl_p[6]}
C {devices/lab_pin.sym} 5730 -1230 0 0 {name=lp_ctrl_n[6] lab=ctrl_n[6]}
C {sg13g2_pr/sg13_lv_nmos.sym} 6380 -860 0 0 {name=M4_07 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 6590 -860 0 1 {name=M8_07 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 6750 -860 0 0 {name=M9_07 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 6960 -860 0 1 {name=M10_07 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 6670 -750 2 0 {name=R1_07 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 6670 -980 2 0 {name=R2_07 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 6670 -510 0 0 {name=lp_Drain[7] lab=Drain[7]}
C {devices/lab_pin.sym} 6590 -1230 0 0 {name=lp_ctrl_p[7] lab=ctrl_p[7]}
C {devices/lab_pin.sym} 6630 -1230 0 0 {name=lp_ctrl_n[7] lab=ctrl_n[7]}
C {sg13g2_pr/sg13_lv_nmos.sym} 7280 -860 0 0 {name=M4_08 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 7490 -860 0 1 {name=M8_08 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 7650 -860 0 0 {name=M9_08 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 7860 -860 0 1 {name=M10_08 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 7570 -750 2 0 {name=R1_08 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 7570 -980 2 0 {name=R2_08 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 7570 -510 0 0 {name=lp_Drain[8] lab=Drain[8]}
C {devices/lab_pin.sym} 7490 -1230 0 0 {name=lp_ctrl_p[8] lab=ctrl_p[8]}
C {devices/lab_pin.sym} 7530 -1230 0 0 {name=lp_ctrl_n[8] lab=ctrl_n[8]}
C {sg13g2_pr/sg13_lv_nmos.sym} 8180 -860 0 0 {name=M4_09 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 8390 -860 0 1 {name=M8_09 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 8550 -860 0 0 {name=M9_09 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 8760 -860 0 1 {name=M10_09 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 8470 -750 2 0 {name=R1_09 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 8470 -980 2 0 {name=R2_09 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 8470 -510 0 0 {name=lp_Drain[9] lab=Drain[9]}
C {devices/lab_pin.sym} 8390 -1230 0 0 {name=lp_ctrl_p[9] lab=ctrl_p[9]}
C {devices/lab_pin.sym} 8430 -1230 0 0 {name=lp_ctrl_n[9] lab=ctrl_n[9]}
C {sg13g2_pr/sg13_lv_nmos.sym} 9080 -860 0 0 {name=M4_10 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 9290 -860 0 1 {name=M8_10 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 9450 -860 0 0 {name=M9_10 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 9660 -860 0 1 {name=M10_10 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 9370 -750 2 0 {name=R1_10 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 9370 -980 2 0 {name=R2_10 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 9370 -510 0 0 {name=lp_Drain[10] lab=Drain[10]}
C {devices/lab_pin.sym} 9290 -1230 0 0 {name=lp_ctrl_p[10] lab=ctrl_p[10]}
C {devices/lab_pin.sym} 9330 -1230 0 0 {name=lp_ctrl_n[10] lab=ctrl_n[10]}
C {sg13g2_pr/sg13_lv_nmos.sym} 9980 -860 0 0 {name=M4_11 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 10190 -860 0 1 {name=M8_11 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 10350 -860 0 0 {name=M9_11 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 10560 -860 0 1 {name=M10_11 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 10270 -750 2 0 {name=R1_11 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 10270 -980 2 0 {name=R2_11 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 10270 -510 0 0 {name=lp_Drain[11] lab=Drain[11]}
C {devices/lab_pin.sym} 10190 -1230 0 0 {name=lp_ctrl_p[11] lab=ctrl_p[11]}
C {devices/lab_pin.sym} 10230 -1230 0 0 {name=lp_ctrl_n[11] lab=ctrl_n[11]}
C {sg13g2_pr/sg13_lv_nmos.sym} 10880 -860 0 0 {name=M4_12 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 11090 -860 0 1 {name=M8_12 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 11250 -860 0 0 {name=M9_12 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 11460 -860 0 1 {name=M10_12 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 11170 -750 2 0 {name=R1_12 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 11170 -980 2 0 {name=R2_12 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 11170 -510 0 0 {name=lp_Drain[12] lab=Drain[12]}
C {devices/lab_pin.sym} 11090 -1230 0 0 {name=lp_ctrl_p[12] lab=ctrl_p[12]}
C {devices/lab_pin.sym} 11130 -1230 0 0 {name=lp_ctrl_n[12] lab=ctrl_n[12]}
C {sg13g2_pr/sg13_lv_nmos.sym} 11780 -860 0 0 {name=M4_13 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 11990 -860 0 1 {name=M8_13 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 12150 -860 0 0 {name=M9_13 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 12360 -860 0 1 {name=M10_13 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 12070 -750 2 0 {name=R1_13 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 12070 -980 2 0 {name=R2_13 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 12070 -510 0 0 {name=lp_Drain[13] lab=Drain[13]}
C {devices/lab_pin.sym} 11990 -1230 0 0 {name=lp_ctrl_p[13] lab=ctrl_p[13]}
C {devices/lab_pin.sym} 12030 -1230 0 0 {name=lp_ctrl_n[13] lab=ctrl_n[13]}
C {sg13g2_pr/sg13_lv_nmos.sym} 12680 -860 0 0 {name=M4_14 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 12890 -860 0 1 {name=M8_14 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 13050 -860 0 0 {name=M9_14 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 13260 -860 0 1 {name=M10_14 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 12970 -750 2 0 {name=R1_14 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 12970 -980 2 0 {name=R2_14 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 12970 -510 0 0 {name=lp_Drain[14] lab=Drain[14]}
C {devices/lab_pin.sym} 12890 -1230 0 0 {name=lp_ctrl_p[14] lab=ctrl_p[14]}
C {devices/lab_pin.sym} 12930 -1230 0 0 {name=lp_ctrl_n[14] lab=ctrl_n[14]}
C {sg13g2_pr/sg13_lv_nmos.sym} 13580 -860 0 0 {name=M4_15 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 13790 -860 0 1 {name=M8_15 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 13950 -860 0 0 {name=M9_15 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 14160 -860 0 1 {name=M10_15 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 13870 -750 2 0 {name=R1_15 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 13870 -980 2 0 {name=R2_15 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 13870 -510 0 0 {name=lp_Drain[15] lab=Drain[15]}
C {devices/lab_pin.sym} 13790 -1230 0 0 {name=lp_ctrl_p[15] lab=ctrl_p[15]}
C {devices/lab_pin.sym} 13830 -1230 0 0 {name=lp_ctrl_n[15] lab=ctrl_n[15]}
C {sg13g2_pr/sg13_lv_nmos.sym} 14480 -860 0 0 {name=M4_16 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 14690 -860 0 1 {name=M8_16 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 14850 -860 0 0 {name=M9_16 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 15060 -860 0 1 {name=M10_16 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 14770 -750 2 0 {name=R1_16 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 14770 -980 2 0 {name=R2_16 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 14770 -510 0 0 {name=lp_Drain[16] lab=Drain[16]}
C {devices/lab_pin.sym} 14690 -1230 0 0 {name=lp_ctrl_p[16] lab=ctrl_p[16]}
C {devices/lab_pin.sym} 14730 -1230 0 0 {name=lp_ctrl_n[16] lab=ctrl_n[16]}
C {sg13g2_pr/sg13_lv_nmos.sym} 15380 -860 0 0 {name=M4_17 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 15590 -860 0 1 {name=M8_17 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 15750 -860 0 0 {name=M9_17 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 15960 -860 0 1 {name=M10_17 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 15670 -750 2 0 {name=R1_17 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 15670 -980 2 0 {name=R2_17 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 15670 -510 0 0 {name=lp_Drain[17] lab=Drain[17]}
C {devices/lab_pin.sym} 15590 -1230 0 0 {name=lp_ctrl_p[17] lab=ctrl_p[17]}
C {devices/lab_pin.sym} 15630 -1230 0 0 {name=lp_ctrl_n[17] lab=ctrl_n[17]}
C {sg13g2_pr/sg13_lv_nmos.sym} 16280 -860 0 0 {name=M4_18 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 16490 -860 0 1 {name=M8_18 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 16650 -860 0 0 {name=M9_18 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 16860 -860 0 1 {name=M10_18 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 16570 -750 2 0 {name=R1_18 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 16570 -980 2 0 {name=R2_18 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 16570 -510 0 0 {name=lp_Drain[18] lab=Drain[18]}
C {devices/lab_pin.sym} 16490 -1230 0 0 {name=lp_ctrl_p[18] lab=ctrl_p[18]}
C {devices/lab_pin.sym} 16530 -1230 0 0 {name=lp_ctrl_n[18] lab=ctrl_n[18]}
C {sg13g2_pr/sg13_lv_nmos.sym} 17180 -860 0 0 {name=M4_19 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 17390 -860 0 1 {name=M8_19 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 17550 -860 0 0 {name=M9_19 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 17760 -860 0 1 {name=M10_19 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 17470 -750 2 0 {name=R1_19 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 17470 -980 2 0 {name=R2_19 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 17470 -510 0 0 {name=lp_Drain[19] lab=Drain[19]}
C {devices/lab_pin.sym} 17390 -1230 0 0 {name=lp_ctrl_p[19] lab=ctrl_p[19]}
C {devices/lab_pin.sym} 17430 -1230 0 0 {name=lp_ctrl_n[19] lab=ctrl_n[19]}
C {sg13g2_pr/sg13_lv_nmos.sym} 18080 -860 0 0 {name=M4_20 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 18290 -860 0 1 {name=M8_20 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 18450 -860 0 0 {name=M9_20 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 18660 -860 0 1 {name=M10_20 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 18370 -750 2 0 {name=R1_20 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 18370 -980 2 0 {name=R2_20 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 18370 -510 0 0 {name=lp_Drain[20] lab=Drain[20]}
C {devices/lab_pin.sym} 18290 -1230 0 0 {name=lp_ctrl_p[20] lab=ctrl_p[20]}
C {devices/lab_pin.sym} 18330 -1230 0 0 {name=lp_ctrl_n[20] lab=ctrl_n[20]}
C {sg13g2_pr/sg13_lv_nmos.sym} 18980 -860 0 0 {name=M4_21 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 19190 -860 0 1 {name=M8_21 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 19350 -860 0 0 {name=M9_21 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 19560 -860 0 1 {name=M10_21 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 19270 -750 2 0 {name=R1_21 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 19270 -980 2 0 {name=R2_21 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 19270 -510 0 0 {name=lp_Drain[21] lab=Drain[21]}
C {devices/lab_pin.sym} 19190 -1230 0 0 {name=lp_ctrl_p[21] lab=ctrl_p[21]}
C {devices/lab_pin.sym} 19230 -1230 0 0 {name=lp_ctrl_n[21] lab=ctrl_n[21]}
C {sg13g2_pr/sg13_lv_nmos.sym} 19880 -860 0 0 {name=M4_22 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 20090 -860 0 1 {name=M8_22 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 20250 -860 0 0 {name=M9_22 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 20460 -860 0 1 {name=M10_22 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 20170 -750 2 0 {name=R1_22 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 20170 -980 2 0 {name=R2_22 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 20170 -510 0 0 {name=lp_Drain[22] lab=Drain[22]}
C {devices/lab_pin.sym} 20090 -1230 0 0 {name=lp_ctrl_p[22] lab=ctrl_p[22]}
C {devices/lab_pin.sym} 20130 -1230 0 0 {name=lp_ctrl_n[22] lab=ctrl_n[22]}
C {sg13g2_pr/sg13_lv_nmos.sym} 20780 -860 0 0 {name=M4_23 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 20990 -860 0 1 {name=M8_23 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 21150 -860 0 0 {name=M9_23 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 21360 -860 0 1 {name=M10_23 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 21070 -750 2 0 {name=R1_23 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 21070 -980 2 0 {name=R2_23 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 21070 -510 0 0 {name=lp_Drain[23] lab=Drain[23]}
C {devices/lab_pin.sym} 20990 -1230 0 0 {name=lp_ctrl_p[23] lab=ctrl_p[23]}
C {devices/lab_pin.sym} 21030 -1230 0 0 {name=lp_ctrl_n[23] lab=ctrl_n[23]}
C {sg13g2_pr/sg13_lv_nmos.sym} 21680 -860 0 0 {name=M4_24 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 21890 -860 0 1 {name=M8_24 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 22050 -860 0 0 {name=M9_24 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 22260 -860 0 1 {name=M10_24 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 21970 -750 2 0 {name=R1_24 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 21970 -980 2 0 {name=R2_24 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 21970 -510 0 0 {name=lp_Drain[24] lab=Drain[24]}
C {devices/lab_pin.sym} 21890 -1230 0 0 {name=lp_ctrl_p[24] lab=ctrl_p[24]}
C {devices/lab_pin.sym} 21930 -1230 0 0 {name=lp_ctrl_n[24] lab=ctrl_n[24]}
C {sg13g2_pr/sg13_lv_nmos.sym} 22580 -860 0 0 {name=M4_25 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 22790 -860 0 1 {name=M8_25 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 22950 -860 0 0 {name=M9_25 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 23160 -860 0 1 {name=M10_25 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 22870 -750 2 0 {name=R1_25 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 22870 -980 2 0 {name=R2_25 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 22870 -510 0 0 {name=lp_Drain[25] lab=Drain[25]}
C {devices/lab_pin.sym} 22790 -1230 0 0 {name=lp_ctrl_p[25] lab=ctrl_p[25]}
C {devices/lab_pin.sym} 22830 -1230 0 0 {name=lp_ctrl_n[25] lab=ctrl_n[25]}
C {sg13g2_pr/sg13_lv_nmos.sym} 23480 -860 0 0 {name=M4_26 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 23690 -860 0 1 {name=M8_26 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 23850 -860 0 0 {name=M9_26 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 24060 -860 0 1 {name=M10_26 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 23770 -750 2 0 {name=R1_26 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 23770 -980 2 0 {name=R2_26 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 23770 -510 0 0 {name=lp_Drain[26] lab=Drain[26]}
C {devices/lab_pin.sym} 23690 -1230 0 0 {name=lp_ctrl_p[26] lab=ctrl_p[26]}
C {devices/lab_pin.sym} 23730 -1230 0 0 {name=lp_ctrl_n[26] lab=ctrl_n[26]}
C {sg13g2_pr/sg13_lv_nmos.sym} 24380 -860 0 0 {name=M4_27 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 24590 -860 0 1 {name=M8_27 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 24750 -860 0 0 {name=M9_27 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 24960 -860 0 1 {name=M10_27 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 24670 -750 2 0 {name=R1_27 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 24670 -980 2 0 {name=R2_27 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 24670 -510 0 0 {name=lp_Drain[27] lab=Drain[27]}
C {devices/lab_pin.sym} 24590 -1230 0 0 {name=lp_ctrl_p[27] lab=ctrl_p[27]}
C {devices/lab_pin.sym} 24630 -1230 0 0 {name=lp_ctrl_n[27] lab=ctrl_n[27]}
C {sg13g2_pr/sg13_lv_nmos.sym} 25280 -860 0 0 {name=M4_28 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 25490 -860 0 1 {name=M8_28 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 25650 -860 0 0 {name=M9_28 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 25860 -860 0 1 {name=M10_28 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 25570 -750 2 0 {name=R1_28 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 25570 -980 2 0 {name=R2_28 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 25570 -510 0 0 {name=lp_Drain[28] lab=Drain[28]}
C {devices/lab_pin.sym} 25490 -1230 0 0 {name=lp_ctrl_p[28] lab=ctrl_p[28]}
C {devices/lab_pin.sym} 25530 -1230 0 0 {name=lp_ctrl_n[28] lab=ctrl_n[28]}
C {sg13g2_pr/sg13_lv_nmos.sym} 26180 -860 0 0 {name=M4_29 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 26390 -860 0 1 {name=M8_29 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 26550 -860 0 0 {name=M9_29 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 26760 -860 0 1 {name=M10_29 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 26470 -750 2 0 {name=R1_29 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 26470 -980 2 0 {name=R2_29 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 26470 -510 0 0 {name=lp_Drain[29] lab=Drain[29]}
C {devices/lab_pin.sym} 26390 -1230 0 0 {name=lp_ctrl_p[29] lab=ctrl_p[29]}
C {devices/lab_pin.sym} 26430 -1230 0 0 {name=lp_ctrl_n[29] lab=ctrl_n[29]}
C {sg13g2_pr/sg13_lv_nmos.sym} 27080 -860 0 0 {name=M4_30 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 27290 -860 0 1 {name=M8_30 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 27450 -860 0 0 {name=M9_30 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 27660 -860 0 1 {name=M10_30 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 27370 -750 2 0 {name=R1_30 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 27370 -980 2 0 {name=R2_30 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 27370 -510 0 0 {name=lp_Drain[30] lab=Drain[30]}
C {devices/lab_pin.sym} 27290 -1230 0 0 {name=lp_ctrl_p[30] lab=ctrl_p[30]}
C {devices/lab_pin.sym} 27330 -1230 0 0 {name=lp_ctrl_n[30] lab=ctrl_n[30]}
C {sg13g2_pr/sg13_lv_nmos.sym} 27980 -860 0 0 {name=M4_31 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 28190 -860 0 1 {name=M8_31 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 28350 -860 0 0 {name=M9_31 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 28560 -860 0 1 {name=M10_31 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 28270 -750 2 0 {name=R1_31 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 28270 -980 2 0 {name=R2_31 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 28270 -510 0 0 {name=lp_Drain[31] lab=Drain[31]}
C {devices/lab_pin.sym} 28190 -1230 0 0 {name=lp_ctrl_p[31] lab=ctrl_p[31]}
C {devices/lab_pin.sym} 28230 -1230 0 0 {name=lp_ctrl_n[31] lab=ctrl_n[31]}
C {sg13g2_pr/sg13_lv_nmos.sym} 28880 -860 0 0 {name=M4_32 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 29090 -860 0 1 {name=M8_32 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 29250 -860 0 0 {name=M9_32 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 29460 -860 0 1 {name=M10_32 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 29170 -750 2 0 {name=R1_32 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 29170 -980 2 0 {name=R2_32 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 29170 -510 0 0 {name=lp_Drain[32] lab=Drain[32]}
C {devices/lab_pin.sym} 29090 -1230 0 0 {name=lp_ctrl_p[32] lab=ctrl_p[32]}
C {devices/lab_pin.sym} 29130 -1230 0 0 {name=lp_ctrl_n[32] lab=ctrl_n[32]}
C {sg13g2_pr/sg13_lv_nmos.sym} 29780 -860 0 0 {name=M4_33 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 29990 -860 0 1 {name=M8_33 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 30150 -860 0 0 {name=M9_33 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 30360 -860 0 1 {name=M10_33 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 30070 -750 2 0 {name=R1_33 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 30070 -980 2 0 {name=R2_33 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 30070 -510 0 0 {name=lp_Drain[33] lab=Drain[33]}
C {devices/lab_pin.sym} 29990 -1230 0 0 {name=lp_ctrl_p[33] lab=ctrl_p[33]}
C {devices/lab_pin.sym} 30030 -1230 0 0 {name=lp_ctrl_n[33] lab=ctrl_n[33]}
C {sg13g2_pr/sg13_lv_nmos.sym} 30680 -860 0 0 {name=M4_34 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 30890 -860 0 1 {name=M8_34 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 31050 -860 0 0 {name=M9_34 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 31260 -860 0 1 {name=M10_34 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 30970 -750 2 0 {name=R1_34 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 30970 -980 2 0 {name=R2_34 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 30970 -510 0 0 {name=lp_Drain[34] lab=Drain[34]}
C {devices/lab_pin.sym} 30890 -1230 0 0 {name=lp_ctrl_p[34] lab=ctrl_p[34]}
C {devices/lab_pin.sym} 30930 -1230 0 0 {name=lp_ctrl_n[34] lab=ctrl_n[34]}
C {sg13g2_pr/sg13_lv_nmos.sym} 31580 -860 0 0 {name=M4_35 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 31790 -860 0 1 {name=M8_35 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 31950 -860 0 0 {name=M9_35 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 32160 -860 0 1 {name=M10_35 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 31870 -750 2 0 {name=R1_35 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 31870 -980 2 0 {name=R2_35 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 31870 -510 0 0 {name=lp_Drain[35] lab=Drain[35]}
C {devices/lab_pin.sym} 31790 -1230 0 0 {name=lp_ctrl_p[35] lab=ctrl_p[35]}
C {devices/lab_pin.sym} 31830 -1230 0 0 {name=lp_ctrl_n[35] lab=ctrl_n[35]}
C {sg13g2_pr/sg13_lv_nmos.sym} 32480 -860 0 0 {name=M4_36 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 32690 -860 0 1 {name=M8_36 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 32850 -860 0 0 {name=M9_36 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 33060 -860 0 1 {name=M10_36 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 32770 -750 2 0 {name=R1_36 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 32770 -980 2 0 {name=R2_36 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 32770 -510 0 0 {name=lp_Drain[36] lab=Drain[36]}
C {devices/lab_pin.sym} 32690 -1230 0 0 {name=lp_ctrl_p[36] lab=ctrl_p[36]}
C {devices/lab_pin.sym} 32730 -1230 0 0 {name=lp_ctrl_n[36] lab=ctrl_n[36]}
C {sg13g2_pr/sg13_lv_nmos.sym} 33380 -860 0 0 {name=M4_37 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 33590 -860 0 1 {name=M8_37 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 33750 -860 0 0 {name=M9_37 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 33960 -860 0 1 {name=M10_37 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 33670 -750 2 0 {name=R1_37 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 33670 -980 2 0 {name=R2_37 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 33670 -510 0 0 {name=lp_Drain[37] lab=Drain[37]}
C {devices/lab_pin.sym} 33590 -1230 0 0 {name=lp_ctrl_p[37] lab=ctrl_p[37]}
C {devices/lab_pin.sym} 33630 -1230 0 0 {name=lp_ctrl_n[37] lab=ctrl_n[37]}
C {sg13g2_pr/sg13_lv_nmos.sym} 34280 -860 0 0 {name=M4_38 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 34490 -860 0 1 {name=M8_38 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 34650 -860 0 0 {name=M9_38 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 34860 -860 0 1 {name=M10_38 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 34570 -750 2 0 {name=R1_38 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 34570 -980 2 0 {name=R2_38 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 34570 -510 0 0 {name=lp_Drain[38] lab=Drain[38]}
C {devices/lab_pin.sym} 34490 -1230 0 0 {name=lp_ctrl_p[38] lab=ctrl_p[38]}
C {devices/lab_pin.sym} 34530 -1230 0 0 {name=lp_ctrl_n[38] lab=ctrl_n[38]}
C {sg13g2_pr/sg13_lv_nmos.sym} 35180 -860 0 0 {name=M4_39 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 35390 -860 0 1 {name=M8_39 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 35550 -860 0 0 {name=M9_39 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 35760 -860 0 1 {name=M10_39 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 35470 -750 2 0 {name=R1_39 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 35470 -980 2 0 {name=R2_39 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 35470 -510 0 0 {name=lp_Drain[39] lab=Drain[39]}
C {devices/lab_pin.sym} 35390 -1230 0 0 {name=lp_ctrl_p[39] lab=ctrl_p[39]}
C {devices/lab_pin.sym} 35430 -1230 0 0 {name=lp_ctrl_n[39] lab=ctrl_n[39]}
C {sg13g2_pr/sg13_lv_nmos.sym} 36080 -860 0 0 {name=M4_40 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 36290 -860 0 1 {name=M8_40 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 36450 -860 0 0 {name=M9_40 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 36660 -860 0 1 {name=M10_40 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 36370 -750 2 0 {name=R1_40 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 36370 -980 2 0 {name=R2_40 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 36370 -510 0 0 {name=lp_Drain[40] lab=Drain[40]}
C {devices/lab_pin.sym} 36290 -1230 0 0 {name=lp_ctrl_p[40] lab=ctrl_p[40]}
C {devices/lab_pin.sym} 36330 -1230 0 0 {name=lp_ctrl_n[40] lab=ctrl_n[40]}
C {sg13g2_pr/sg13_lv_nmos.sym} 36980 -860 0 0 {name=M4_41 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 37190 -860 0 1 {name=M8_41 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 37350 -860 0 0 {name=M9_41 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 37560 -860 0 1 {name=M10_41 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 37270 -750 2 0 {name=R1_41 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 37270 -980 2 0 {name=R2_41 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 37270 -510 0 0 {name=lp_Drain[41] lab=Drain[41]}
C {devices/lab_pin.sym} 37190 -1230 0 0 {name=lp_ctrl_p[41] lab=ctrl_p[41]}
C {devices/lab_pin.sym} 37230 -1230 0 0 {name=lp_ctrl_n[41] lab=ctrl_n[41]}
C {sg13g2_pr/sg13_lv_nmos.sym} 37880 -860 0 0 {name=M4_42 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 38090 -860 0 1 {name=M8_42 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 38250 -860 0 0 {name=M9_42 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 38460 -860 0 1 {name=M10_42 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 38170 -750 2 0 {name=R1_42 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 38170 -980 2 0 {name=R2_42 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 38170 -510 0 0 {name=lp_Drain[42] lab=Drain[42]}
C {devices/lab_pin.sym} 38090 -1230 0 0 {name=lp_ctrl_p[42] lab=ctrl_p[42]}
C {devices/lab_pin.sym} 38130 -1230 0 0 {name=lp_ctrl_n[42] lab=ctrl_n[42]}
C {sg13g2_pr/sg13_lv_nmos.sym} 38780 -860 0 0 {name=M4_43 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 38990 -860 0 1 {name=M8_43 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 39150 -860 0 0 {name=M9_43 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 39360 -860 0 1 {name=M10_43 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 39070 -750 2 0 {name=R1_43 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 39070 -980 2 0 {name=R2_43 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 39070 -510 0 0 {name=lp_Drain[43] lab=Drain[43]}
C {devices/lab_pin.sym} 38990 -1230 0 0 {name=lp_ctrl_p[43] lab=ctrl_p[43]}
C {devices/lab_pin.sym} 39030 -1230 0 0 {name=lp_ctrl_n[43] lab=ctrl_n[43]}
C {sg13g2_pr/sg13_lv_nmos.sym} 39680 -860 0 0 {name=M4_44 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 39890 -860 0 1 {name=M8_44 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 40050 -860 0 0 {name=M9_44 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 40260 -860 0 1 {name=M10_44 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 39970 -750 2 0 {name=R1_44 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 39970 -980 2 0 {name=R2_44 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 39970 -510 0 0 {name=lp_Drain[44] lab=Drain[44]}
C {devices/lab_pin.sym} 39890 -1230 0 0 {name=lp_ctrl_p[44] lab=ctrl_p[44]}
C {devices/lab_pin.sym} 39930 -1230 0 0 {name=lp_ctrl_n[44] lab=ctrl_n[44]}
C {sg13g2_pr/sg13_lv_nmos.sym} 40580 -860 0 0 {name=M4_45 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 40790 -860 0 1 {name=M8_45 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 40950 -860 0 0 {name=M9_45 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 41160 -860 0 1 {name=M10_45 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 40870 -750 2 0 {name=R1_45 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 40870 -980 2 0 {name=R2_45 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 40870 -510 0 0 {name=lp_Drain[45] lab=Drain[45]}
C {devices/lab_pin.sym} 40790 -1230 0 0 {name=lp_ctrl_p[45] lab=ctrl_p[45]}
C {devices/lab_pin.sym} 40830 -1230 0 0 {name=lp_ctrl_n[45] lab=ctrl_n[45]}
C {sg13g2_pr/sg13_lv_nmos.sym} 41480 -860 0 0 {name=M4_46 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 41690 -860 0 1 {name=M8_46 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 41850 -860 0 0 {name=M9_46 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 42060 -860 0 1 {name=M10_46 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 41770 -750 2 0 {name=R1_46 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 41770 -980 2 0 {name=R2_46 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 41770 -510 0 0 {name=lp_Drain[46] lab=Drain[46]}
C {devices/lab_pin.sym} 41690 -1230 0 0 {name=lp_ctrl_p[46] lab=ctrl_p[46]}
C {devices/lab_pin.sym} 41730 -1230 0 0 {name=lp_ctrl_n[46] lab=ctrl_n[46]}
C {sg13g2_pr/sg13_lv_nmos.sym} 42380 -860 0 0 {name=M4_47 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 42590 -860 0 1 {name=M8_47 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 42750 -860 0 0 {name=M9_47 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 42960 -860 0 1 {name=M10_47 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 42670 -750 2 0 {name=R1_47 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 42670 -980 2 0 {name=R2_47 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 42670 -510 0 0 {name=lp_Drain[47] lab=Drain[47]}
C {devices/lab_pin.sym} 42590 -1230 0 0 {name=lp_ctrl_p[47] lab=ctrl_p[47]}
C {devices/lab_pin.sym} 42630 -1230 0 0 {name=lp_ctrl_n[47] lab=ctrl_n[47]}
C {sg13g2_pr/sg13_lv_nmos.sym} 43280 -860 0 0 {name=M4_48 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 43490 -860 0 1 {name=M8_48 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 43650 -860 0 0 {name=M9_48 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 43860 -860 0 1 {name=M10_48 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 43570 -750 2 0 {name=R1_48 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 43570 -980 2 0 {name=R2_48 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 43570 -510 0 0 {name=lp_Drain[48] lab=Drain[48]}
C {devices/lab_pin.sym} 43490 -1230 0 0 {name=lp_ctrl_p[48] lab=ctrl_p[48]}
C {devices/lab_pin.sym} 43530 -1230 0 0 {name=lp_ctrl_n[48] lab=ctrl_n[48]}
C {sg13g2_pr/sg13_lv_nmos.sym} 44180 -860 0 0 {name=M4_49 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 44390 -860 0 1 {name=M8_49 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 44550 -860 0 0 {name=M9_49 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 44760 -860 0 1 {name=M10_49 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 44470 -750 2 0 {name=R1_49 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 44470 -980 2 0 {name=R2_49 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 44470 -510 0 0 {name=lp_Drain[49] lab=Drain[49]}
C {devices/lab_pin.sym} 44390 -1230 0 0 {name=lp_ctrl_p[49] lab=ctrl_p[49]}
C {devices/lab_pin.sym} 44430 -1230 0 0 {name=lp_ctrl_n[49] lab=ctrl_n[49]}
C {sg13g2_pr/sg13_lv_nmos.sym} 45080 -860 0 0 {name=M4_50 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 45290 -860 0 1 {name=M8_50 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 45450 -860 0 0 {name=M9_50 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 45660 -860 0 1 {name=M10_50 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 45370 -750 2 0 {name=R1_50 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 45370 -980 2 0 {name=R2_50 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 45370 -510 0 0 {name=lp_Drain[50] lab=Drain[50]}
C {devices/lab_pin.sym} 45290 -1230 0 0 {name=lp_ctrl_p[50] lab=ctrl_p[50]}
C {devices/lab_pin.sym} 45330 -1230 0 0 {name=lp_ctrl_n[50] lab=ctrl_n[50]}
C {sg13g2_pr/sg13_lv_nmos.sym} 45980 -860 0 0 {name=M4_51 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 46190 -860 0 1 {name=M8_51 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 46350 -860 0 0 {name=M9_51 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 46560 -860 0 1 {name=M10_51 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 46270 -750 2 0 {name=R1_51 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 46270 -980 2 0 {name=R2_51 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 46270 -510 0 0 {name=lp_Drain[51] lab=Drain[51]}
C {devices/lab_pin.sym} 46190 -1230 0 0 {name=lp_ctrl_p[51] lab=ctrl_p[51]}
C {devices/lab_pin.sym} 46230 -1230 0 0 {name=lp_ctrl_n[51] lab=ctrl_n[51]}
C {sg13g2_pr/sg13_lv_nmos.sym} 46880 -860 0 0 {name=M4_52 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 47090 -860 0 1 {name=M8_52 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 47250 -860 0 0 {name=M9_52 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 47460 -860 0 1 {name=M10_52 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 47170 -750 2 0 {name=R1_52 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 47170 -980 2 0 {name=R2_52 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 47170 -510 0 0 {name=lp_Drain[52] lab=Drain[52]}
C {devices/lab_pin.sym} 47090 -1230 0 0 {name=lp_ctrl_p[52] lab=ctrl_p[52]}
C {devices/lab_pin.sym} 47130 -1230 0 0 {name=lp_ctrl_n[52] lab=ctrl_n[52]}
C {sg13g2_pr/sg13_lv_nmos.sym} 47780 -860 0 0 {name=M4_53 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 47990 -860 0 1 {name=M8_53 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 48150 -860 0 0 {name=M9_53 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 48360 -860 0 1 {name=M10_53 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 48070 -750 2 0 {name=R1_53 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 48070 -980 2 0 {name=R2_53 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 48070 -510 0 0 {name=lp_Drain[53] lab=Drain[53]}
C {devices/lab_pin.sym} 47990 -1230 0 0 {name=lp_ctrl_p[53] lab=ctrl_p[53]}
C {devices/lab_pin.sym} 48030 -1230 0 0 {name=lp_ctrl_n[53] lab=ctrl_n[53]}
C {sg13g2_pr/sg13_lv_nmos.sym} 48680 -860 0 0 {name=M4_54 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 48890 -860 0 1 {name=M8_54 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 49050 -860 0 0 {name=M9_54 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 49260 -860 0 1 {name=M10_54 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 48970 -750 2 0 {name=R1_54 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 48970 -980 2 0 {name=R2_54 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 48970 -510 0 0 {name=lp_Drain[54] lab=Drain[54]}
C {devices/lab_pin.sym} 48890 -1230 0 0 {name=lp_ctrl_p[54] lab=ctrl_p[54]}
C {devices/lab_pin.sym} 48930 -1230 0 0 {name=lp_ctrl_n[54] lab=ctrl_n[54]}
C {sg13g2_pr/sg13_lv_nmos.sym} 49580 -860 0 0 {name=M4_55 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 49790 -860 0 1 {name=M8_55 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 49950 -860 0 0 {name=M9_55 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 50160 -860 0 1 {name=M10_55 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 49870 -750 2 0 {name=R1_55 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 49870 -980 2 0 {name=R2_55 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 49870 -510 0 0 {name=lp_Drain[55] lab=Drain[55]}
C {devices/lab_pin.sym} 49790 -1230 0 0 {name=lp_ctrl_p[55] lab=ctrl_p[55]}
C {devices/lab_pin.sym} 49830 -1230 0 0 {name=lp_ctrl_n[55] lab=ctrl_n[55]}
C {sg13g2_pr/sg13_lv_nmos.sym} 50480 -860 0 0 {name=M4_56 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 50690 -860 0 1 {name=M8_56 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 50850 -860 0 0 {name=M9_56 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 51060 -860 0 1 {name=M10_56 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 50770 -750 2 0 {name=R1_56 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 50770 -980 2 0 {name=R2_56 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 50770 -510 0 0 {name=lp_Drain[56] lab=Drain[56]}
C {devices/lab_pin.sym} 50690 -1230 0 0 {name=lp_ctrl_p[56] lab=ctrl_p[56]}
C {devices/lab_pin.sym} 50730 -1230 0 0 {name=lp_ctrl_n[56] lab=ctrl_n[56]}
C {sg13g2_pr/sg13_lv_nmos.sym} 51380 -860 0 0 {name=M4_57 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 51590 -860 0 1 {name=M8_57 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 51750 -860 0 0 {name=M9_57 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 51960 -860 0 1 {name=M10_57 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 51670 -750 2 0 {name=R1_57 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 51670 -980 2 0 {name=R2_57 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 51670 -510 0 0 {name=lp_Drain[57] lab=Drain[57]}
C {devices/lab_pin.sym} 51590 -1230 0 0 {name=lp_ctrl_p[57] lab=ctrl_p[57]}
C {devices/lab_pin.sym} 51630 -1230 0 0 {name=lp_ctrl_n[57] lab=ctrl_n[57]}
C {sg13g2_pr/sg13_lv_nmos.sym} 52280 -860 0 0 {name=M4_58 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 52490 -860 0 1 {name=M8_58 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 52650 -860 0 0 {name=M9_58 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 52860 -860 0 1 {name=M10_58 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 52570 -750 2 0 {name=R1_58 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 52570 -980 2 0 {name=R2_58 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 52570 -510 0 0 {name=lp_Drain[58] lab=Drain[58]}
C {devices/lab_pin.sym} 52490 -1230 0 0 {name=lp_ctrl_p[58] lab=ctrl_p[58]}
C {devices/lab_pin.sym} 52530 -1230 0 0 {name=lp_ctrl_n[58] lab=ctrl_n[58]}
C {sg13g2_pr/sg13_lv_nmos.sym} 53180 -860 0 0 {name=M4_59 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 53390 -860 0 1 {name=M8_59 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 53550 -860 0 0 {name=M9_59 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 53760 -860 0 1 {name=M10_59 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 53470 -750 2 0 {name=R1_59 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 53470 -980 2 0 {name=R2_59 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 53470 -510 0 0 {name=lp_Drain[59] lab=Drain[59]}
C {devices/lab_pin.sym} 53390 -1230 0 0 {name=lp_ctrl_p[59] lab=ctrl_p[59]}
C {devices/lab_pin.sym} 53430 -1230 0 0 {name=lp_ctrl_n[59] lab=ctrl_n[59]}
C {sg13g2_pr/sg13_lv_nmos.sym} 54080 -860 0 0 {name=M4_60 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 54290 -860 0 1 {name=M8_60 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 54450 -860 0 0 {name=M9_60 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 54660 -860 0 1 {name=M10_60 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 54370 -750 2 0 {name=R1_60 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 54370 -980 2 0 {name=R2_60 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 54370 -510 0 0 {name=lp_Drain[60] lab=Drain[60]}
C {devices/lab_pin.sym} 54290 -1230 0 0 {name=lp_ctrl_p[60] lab=ctrl_p[60]}
C {devices/lab_pin.sym} 54330 -1230 0 0 {name=lp_ctrl_n[60] lab=ctrl_n[60]}
C {sg13g2_pr/sg13_lv_nmos.sym} 54980 -860 0 0 {name=M4_61 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 55190 -860 0 1 {name=M8_61 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 55350 -860 0 0 {name=M9_61 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 55560 -860 0 1 {name=M10_61 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 55270 -750 2 0 {name=R1_61 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 55270 -980 2 0 {name=R2_61 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 55270 -510 0 0 {name=lp_Drain[61] lab=Drain[61]}
C {devices/lab_pin.sym} 55190 -1230 0 0 {name=lp_ctrl_p[61] lab=ctrl_p[61]}
C {devices/lab_pin.sym} 55230 -1230 0 0 {name=lp_ctrl_n[61] lab=ctrl_n[61]}
C {sg13g2_pr/sg13_lv_nmos.sym} 55880 -860 0 0 {name=M4_62 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 56090 -860 0 1 {name=M8_62 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 56250 -860 0 0 {name=M9_62 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 56460 -860 0 1 {name=M10_62 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 56170 -750 2 0 {name=R1_62 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 56170 -980 2 0 {name=R2_62 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 56170 -510 0 0 {name=lp_Drain[62] lab=Drain[62]}
C {devices/lab_pin.sym} 56090 -1230 0 0 {name=lp_ctrl_p[62] lab=ctrl_p[62]}
C {devices/lab_pin.sym} 56130 -1230 0 0 {name=lp_ctrl_n[62] lab=ctrl_n[62]}
C {sg13g2_pr/sg13_lv_nmos.sym} 56780 -860 0 0 {name=M4_63 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 56990 -860 0 1 {name=M8_63 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 57150 -860 0 0 {name=M9_63 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 57360 -860 0 1 {name=M10_63 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 57070 -750 2 0 {name=R1_63 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 57070 -980 2 0 {name=R2_63 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 57070 -510 0 0 {name=lp_Drain[63] lab=Drain[63]}
C {devices/lab_pin.sym} 56990 -1230 0 0 {name=lp_ctrl_p[63] lab=ctrl_p[63]}
C {devices/lab_pin.sym} 57030 -1230 0 0 {name=lp_ctrl_n[63] lab=ctrl_n[63]}
C {sg13g2_pr/sg13_lv_nmos.sym} 57680 -860 0 0 {name=M4_64 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 57890 -860 0 1 {name=M8_64 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 58050 -860 0 0 {name=M9_64 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 58260 -860 0 1 {name=M10_64 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 57970 -750 2 0 {name=R1_64 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 57970 -980 2 0 {name=R2_64 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 57970 -510 0 0 {name=lp_Drain[64] lab=Drain[64]}
C {devices/lab_pin.sym} 57890 -1230 0 0 {name=lp_ctrl_p[64] lab=ctrl_p[64]}
C {devices/lab_pin.sym} 57930 -1230 0 0 {name=lp_ctrl_n[64] lab=ctrl_n[64]}
C {sg13g2_pr/sg13_lv_nmos.sym} 58580 -860 0 0 {name=M4_65 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 58790 -860 0 1 {name=M8_65 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 58950 -860 0 0 {name=M9_65 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 59160 -860 0 1 {name=M10_65 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 58870 -750 2 0 {name=R1_65 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 58870 -980 2 0 {name=R2_65 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 58870 -510 0 0 {name=lp_Drain[65] lab=Drain[65]}
C {devices/lab_pin.sym} 58790 -1230 0 0 {name=lp_ctrl_p[65] lab=ctrl_p[65]}
C {devices/lab_pin.sym} 58830 -1230 0 0 {name=lp_ctrl_n[65] lab=ctrl_n[65]}
C {sg13g2_pr/sg13_lv_nmos.sym} 59480 -860 0 0 {name=M4_66 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 59690 -860 0 1 {name=M8_66 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 59850 -860 0 0 {name=M9_66 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 60060 -860 0 1 {name=M10_66 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 59770 -750 2 0 {name=R1_66 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 59770 -980 2 0 {name=R2_66 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 59770 -510 0 0 {name=lp_Drain[66] lab=Drain[66]}
C {devices/lab_pin.sym} 59690 -1230 0 0 {name=lp_ctrl_p[66] lab=ctrl_p[66]}
C {devices/lab_pin.sym} 59730 -1230 0 0 {name=lp_ctrl_n[66] lab=ctrl_n[66]}
C {sg13g2_pr/sg13_lv_nmos.sym} 60380 -860 0 0 {name=M4_67 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 60590 -860 0 1 {name=M8_67 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 60750 -860 0 0 {name=M9_67 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 60960 -860 0 1 {name=M10_67 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 60670 -750 2 0 {name=R1_67 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 60670 -980 2 0 {name=R2_67 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 60670 -510 0 0 {name=lp_Drain[67] lab=Drain[67]}
C {devices/lab_pin.sym} 60590 -1230 0 0 {name=lp_ctrl_p[67] lab=ctrl_p[67]}
C {devices/lab_pin.sym} 60630 -1230 0 0 {name=lp_ctrl_n[67] lab=ctrl_n[67]}
C {sg13g2_pr/sg13_lv_nmos.sym} 61280 -860 0 0 {name=M4_68 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 61490 -860 0 1 {name=M8_68 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 61650 -860 0 0 {name=M9_68 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 61860 -860 0 1 {name=M10_68 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 61570 -750 2 0 {name=R1_68 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 61570 -980 2 0 {name=R2_68 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 61570 -510 0 0 {name=lp_Drain[68] lab=Drain[68]}
C {devices/lab_pin.sym} 61490 -1230 0 0 {name=lp_ctrl_p[68] lab=ctrl_p[68]}
C {devices/lab_pin.sym} 61530 -1230 0 0 {name=lp_ctrl_n[68] lab=ctrl_n[68]}
C {sg13g2_pr/sg13_lv_nmos.sym} 62180 -860 0 0 {name=M4_69 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 62390 -860 0 1 {name=M8_69 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 62550 -860 0 0 {name=M9_69 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 62760 -860 0 1 {name=M10_69 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 62470 -750 2 0 {name=R1_69 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 62470 -980 2 0 {name=R2_69 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 62470 -510 0 0 {name=lp_Drain[69] lab=Drain[69]}
C {devices/lab_pin.sym} 62390 -1230 0 0 {name=lp_ctrl_p[69] lab=ctrl_p[69]}
C {devices/lab_pin.sym} 62430 -1230 0 0 {name=lp_ctrl_n[69] lab=ctrl_n[69]}
C {sg13g2_pr/sg13_lv_nmos.sym} 63080 -860 0 0 {name=M4_70 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 63290 -860 0 1 {name=M8_70 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 63450 -860 0 0 {name=M9_70 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 63660 -860 0 1 {name=M10_70 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 63370 -750 2 0 {name=R1_70 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 63370 -980 2 0 {name=R2_70 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 63370 -510 0 0 {name=lp_Drain[70] lab=Drain[70]}
C {devices/lab_pin.sym} 63290 -1230 0 0 {name=lp_ctrl_p[70] lab=ctrl_p[70]}
C {devices/lab_pin.sym} 63330 -1230 0 0 {name=lp_ctrl_n[70] lab=ctrl_n[70]}
C {sg13g2_pr/sg13_lv_nmos.sym} 63980 -860 0 0 {name=M4_71 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 64190 -860 0 1 {name=M8_71 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 64350 -860 0 0 {name=M9_71 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 64560 -860 0 1 {name=M10_71 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 64270 -750 2 0 {name=R1_71 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 64270 -980 2 0 {name=R2_71 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 64270 -510 0 0 {name=lp_Drain[71] lab=Drain[71]}
C {devices/lab_pin.sym} 64190 -1230 0 0 {name=lp_ctrl_p[71] lab=ctrl_p[71]}
C {devices/lab_pin.sym} 64230 -1230 0 0 {name=lp_ctrl_n[71] lab=ctrl_n[71]}
C {sg13g2_pr/sg13_lv_nmos.sym} 64880 -860 0 0 {name=M4_72 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 65090 -860 0 1 {name=M8_72 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 65250 -860 0 0 {name=M9_72 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 65460 -860 0 1 {name=M10_72 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 65170 -750 2 0 {name=R1_72 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 65170 -980 2 0 {name=R2_72 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 65170 -510 0 0 {name=lp_Drain[72] lab=Drain[72]}
C {devices/lab_pin.sym} 65090 -1230 0 0 {name=lp_ctrl_p[72] lab=ctrl_p[72]}
C {devices/lab_pin.sym} 65130 -1230 0 0 {name=lp_ctrl_n[72] lab=ctrl_n[72]}
C {sg13g2_pr/sg13_lv_nmos.sym} 65780 -860 0 0 {name=M4_73 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 65990 -860 0 1 {name=M8_73 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 66150 -860 0 0 {name=M9_73 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 66360 -860 0 1 {name=M10_73 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 66070 -750 2 0 {name=R1_73 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 66070 -980 2 0 {name=R2_73 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 66070 -510 0 0 {name=lp_Drain[73] lab=Drain[73]}
C {devices/lab_pin.sym} 65990 -1230 0 0 {name=lp_ctrl_p[73] lab=ctrl_p[73]}
C {devices/lab_pin.sym} 66030 -1230 0 0 {name=lp_ctrl_n[73] lab=ctrl_n[73]}
C {sg13g2_pr/sg13_lv_nmos.sym} 66680 -860 0 0 {name=M4_74 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 66890 -860 0 1 {name=M8_74 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 67050 -860 0 0 {name=M9_74 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 67260 -860 0 1 {name=M10_74 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 66970 -750 2 0 {name=R1_74 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 66970 -980 2 0 {name=R2_74 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 66970 -510 0 0 {name=lp_Drain[74] lab=Drain[74]}
C {devices/lab_pin.sym} 66890 -1230 0 0 {name=lp_ctrl_p[74] lab=ctrl_p[74]}
C {devices/lab_pin.sym} 66930 -1230 0 0 {name=lp_ctrl_n[74] lab=ctrl_n[74]}
C {sg13g2_pr/sg13_lv_nmos.sym} 67580 -860 0 0 {name=M4_75 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 67790 -860 0 1 {name=M8_75 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 67950 -860 0 0 {name=M9_75 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 68160 -860 0 1 {name=M10_75 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 67870 -750 2 0 {name=R1_75 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 67870 -980 2 0 {name=R2_75 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 67870 -510 0 0 {name=lp_Drain[75] lab=Drain[75]}
C {devices/lab_pin.sym} 67790 -1230 0 0 {name=lp_ctrl_p[75] lab=ctrl_p[75]}
C {devices/lab_pin.sym} 67830 -1230 0 0 {name=lp_ctrl_n[75] lab=ctrl_n[75]}
C {sg13g2_pr/sg13_lv_nmos.sym} 68480 -860 0 0 {name=M4_76 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 68690 -860 0 1 {name=M8_76 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 68850 -860 0 0 {name=M9_76 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 69060 -860 0 1 {name=M10_76 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 68770 -750 2 0 {name=R1_76 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 68770 -980 2 0 {name=R2_76 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 68770 -510 0 0 {name=lp_Drain[76] lab=Drain[76]}
C {devices/lab_pin.sym} 68690 -1230 0 0 {name=lp_ctrl_p[76] lab=ctrl_p[76]}
C {devices/lab_pin.sym} 68730 -1230 0 0 {name=lp_ctrl_n[76] lab=ctrl_n[76]}
C {sg13g2_pr/sg13_lv_nmos.sym} 69380 -860 0 0 {name=M4_77 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 69590 -860 0 1 {name=M8_77 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 69750 -860 0 0 {name=M9_77 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 69960 -860 0 1 {name=M10_77 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 69670 -750 2 0 {name=R1_77 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 69670 -980 2 0 {name=R2_77 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 69670 -510 0 0 {name=lp_Drain[77] lab=Drain[77]}
C {devices/lab_pin.sym} 69590 -1230 0 0 {name=lp_ctrl_p[77] lab=ctrl_p[77]}
C {devices/lab_pin.sym} 69630 -1230 0 0 {name=lp_ctrl_n[77] lab=ctrl_n[77]}
C {sg13g2_pr/sg13_lv_nmos.sym} 70280 -860 0 0 {name=M4_78 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 70490 -860 0 1 {name=M8_78 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 70650 -860 0 0 {name=M9_78 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 70860 -860 0 1 {name=M10_78 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 70570 -750 2 0 {name=R1_78 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 70570 -980 2 0 {name=R2_78 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 70570 -510 0 0 {name=lp_Drain[78] lab=Drain[78]}
C {devices/lab_pin.sym} 70490 -1230 0 0 {name=lp_ctrl_p[78] lab=ctrl_p[78]}
C {devices/lab_pin.sym} 70530 -1230 0 0 {name=lp_ctrl_n[78] lab=ctrl_n[78]}
C {sg13g2_pr/sg13_lv_nmos.sym} 71180 -860 0 0 {name=M4_79 l=\{m1_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 71390 -860 0 1 {name=M8_79 l=\{m2_l}
C {sg13g2_pr/sg13_lv_pmos.sym} 71550 -860 0 0 {name=M9_79 l=\{m2_l}
C {sg13g2_pr/sg13_lv_nmos.sym} 71760 -860 0 1 {name=M10_79 l=\{m1_l}
C {sg13g2_pr/ptap1.sym} 71470 -750 2 0 {name=R1_79 model=ptap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {sg13g2_pr/ntap1.sym} 71470 -980 2 0 {name=R2_79 model=ntap1 spiceprefix=X w=10.0e-6 l=1.0e-6}
C {devices/lab_pin.sym} 71470 -510 0 0 {name=lp_Drain[79] lab=Drain[79]}
C {devices/lab_pin.sym} 71390 -1230 0 0 {name=lp_ctrl_p[79] lab=ctrl_p[79]}
C {devices/lab_pin.sym} 71430 -1230 0 0 {name=lp_ctrl_n[79] lab=ctrl_n[79]}
C {devices/iopin.sym} 510 -1090 0 0 {name=p_Dsense lab=Dsense}
C {devices/iopin.sym} 510 -1060 0 0 {name=p_Dforce lab=Dforce}
C {devices/iopin.sym} 510 -1030 0 0 {name=p_1.2V lab=1.2V}
C {devices/iopin.sym} 510 -1000 0 0 {name=p_Vss lab=Vss}
