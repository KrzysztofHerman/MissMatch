v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {DUT_final.sym} 200 0 0 0 {name=x1}
