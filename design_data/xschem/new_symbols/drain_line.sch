v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {/home/designer/shared/verification/simulations/ihp-sg13g2/MissMatch/design_data/xschem/new_tg/Drain_Line_Matrix80.sym} 60 -10 1 0 {name=x1}
